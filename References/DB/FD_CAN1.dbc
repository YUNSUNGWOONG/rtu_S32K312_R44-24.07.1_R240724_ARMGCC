VERSION ""

NS_ :

BS_:

BU_: ECS Dummy CGW MFC SPAS ESC BSD SCC SAS MDPS HUD CLU

BO_ 122 ECS_03_10ms: 32 ECS
 SG_ ECSIVSS_ECUVertAccelSnsrVal : 200|12@1+ (0.01,10.24) [0|0] "m/s^2"  Dummy
 SG_ ECSIVSS_RdIndxVal : 212|4@1+ (1,0) [0|0] "-"  Dummy

BA_DEF_ BO_  "NmAsrMessage" ENUM  "No","Yes";
BA_DEF_ BO_  "GenMsgCycleTime" INT 0 2000;
BA_DEF_ BO_  "GenMsgSendType" ENUM  "Cyclic","NoMsgSendType";
BA_DEF_ BO_  "GenMsgCycleTimeFast" INT 0 500;
BA_DEF_ BO_  "GenMsgDelayTime" INT 0 20;
BA_DEF_ BO_  "GenMsgILSupport" ENUM  "No","Yes";
BA_DEF_ BO_  "GenMsgNrOfRepetition" INT 0 3;
BA_DEF_ BO_  "VFrameFormat" ENUM  "StandardCAN","ExtendedCAN","reserved","reserved","reserved","reserved","reserved","reserved","reserved","reserved","reserved","reserved","reserved","reserved","StandardCAN_FD","ExtendedCAN_FD";
BA_DEF_ SG_  "SignalLongName" STRING ;
BA_DEF_ SG_  "UserSigValidity" ENUM  "B+","ACC","IG","IG1","IG2","IG3","IG1 or IG2","IG1 or IG3","Undef";
BA_DEF_ SG_  "GenSigTimeoutTime" INT 0 7000;
BA_DEF_ SG_  "UsrSigTimeoutValue" STRING ;
BA_DEF_ SG_  "UsrSigPurpose" ENUM  "Undef","FN","DIAG","DEV","NM";
BA_DEF_ SG_  "GenSigStartValue" INT 0 1215752192;
BA_DEF_ SG_  "NetworkRequest" ENUM  "Yes","No";
BA_DEF_ SG_  "NetworkRequestHoldingTime" INT 0 65535;
BA_DEF_ SG_  "Description" STRING ;
BA_DEF_ SG_  "Version" STRING ;
BA_DEF_ SG_  "GenSigEnvVarType" ENUM  "Int","Float","Undef";
BA_DEF_ SG_  "GenSigSendType" ENUM  "OnChangeWithRepetition","OnWriteWithRepetition","NoSigSendType";
BA_DEF_ SG_  "GwSigLatencyTime" INT 0 65536;
BA_DEF_ SG_  "GwSigMissingSourceType" ENUM  "Undef","OldValue","DefaultValue","InitialValue";
BA_DEF_ SG_  "RoutingFactor" INT 1 1215752192;
BA_DEF_ SG_  "RoutingFactorMM" INT 1 1215752192;
BA_DEF_DEF_  "NmAsrMessage" "No";
BA_DEF_DEF_  "GenMsgCycleTime" 200;
BA_DEF_DEF_  "GenMsgSendType" "NoMsgSendType";
BA_DEF_DEF_  "GenMsgCycleTimeFast" 40;
BA_DEF_DEF_  "GenMsgDelayTime" 20;
BA_DEF_DEF_  "GenMsgILSupport" "Yes";
BA_DEF_DEF_  "GenMsgNrOfRepetition" 3;
BA_DEF_DEF_  "VFrameFormat" "StandardCAN";
BA_DEF_DEF_  "SignalLongName" "";
BA_DEF_DEF_  "UserSigValidity" "IG";
BA_DEF_DEF_  "GenSigTimeoutTime" 500;
BA_DEF_DEF_  "UsrSigTimeoutValue" "Undef";
BA_DEF_DEF_  "UsrSigPurpose" "FN";
BA_DEF_DEF_  "GenSigStartValue" 0;
BA_DEF_DEF_  "NetworkRequest" "No";
BA_DEF_DEF_  "NetworkRequestHoldingTime" 5.03070881554866E-316;
BA_DEF_DEF_  "Description" "";
BA_DEF_DEF_  "Version" "";
BA_DEF_DEF_  "GenSigEnvVarType" "Undef";
BA_DEF_DEF_  "GenSigSendType" "NoSigSendType";
BA_DEF_DEF_  "GwSigLatencyTime" 40;
BA_DEF_DEF_  "GwSigMissingSourceType" "Undef";
BA_DEF_DEF_  "RoutingFactor" 1;
BA_DEF_DEF_  "RoutingFactorMM" 1;
BA_ "Version" SG_ 122 ECSIVSS_ECUVertAccelSnsrVal "1.0";
BA_ "Description" SG_ 122 ECSIVSS_ECUVertAccelSnsrVal "ECU Inertial Sensor - Acceleration (Vertical)";
BA_ "UsrSigTimeoutValue" SG_ 122 ECSIVSS_ECUVertAccelSnsrVal "";
BA_ "UserSigValidity" SG_ 122 ECSIVSS_ECUVertAccelSnsrVal 3;
BA_ "SignalLongName" SG_ 122 ECSIVSS_ECUVertAccelSnsrVal "ECSIVSS_ECUVerticalAccelerationSensorValue";
BA_ "Version" SG_ 122 ECSIVSS_RdIndxVal "1.0";
BA_ "Description" SG_ 122 ECSIVSS_RdIndxVal "Road Index";
BA_ "UsrSigTimeoutValue" SG_ 122 ECSIVSS_RdIndxVal "";
BA_ "UserSigValidity" SG_ 122 ECSIVSS_RdIndxVal 3;
BA_ "SignalLongName" SG_ 122 ECSIVSS_RdIndxVal "ECSIVSS_RoadIndexValue";
VAL_ 122 ECSIVSS_ECUVertAccelSnsrVal 0 "-20.48~20.45 (m/s²)" 1 "-20.48~20.45 (m/s²)" 2 "-20.48~20.45 (m/s²)" 3 "-20.48~20.45 (m/s²)" 4 "-20.48~20.45 (m/s²)" 5 "-20.48~20.45 (m/s²)" 6 "-20.48~20.45 (m/s²)" 7 "-20.48~20.45 (m/s²)" 8 "-20.48~20.45 (m/s²)" 9 "-20.48~20.45 (m/s²)" 10 "-20.48~20.45 (m/s²)" 11 "-20.48~20.45 (m/s²)" 12 "-20.48~20.45 (m/s²)" 13 "-20.48~20.45 (m/s²)" 14 "-20.48~20.45 (m/s²)" 15 "-20.48~20.45 (m/s²)" 16 "-20.48~20.45 (m/s²)" 17 "-20.48~20.45 (m/s²)" 18 "-20.48~20.45 (m/s²)" 19 "-20.48~20.45 (m/s²)" 20 "-20.48~20.45 (m/s²)" 21 "-20.48~20.45 (m/s²)" 22 "-20.48~20.45 (m/s²)" 23 "-20.48~20.45 (m/s²)" 24 "-20.48~20.45 (m/s²)" 25 "-20.48~20.45 (m/s²)" 26 "-20.48~20.45 (m/s²)" 27 "-20.48~20.45 (m/s²)" 28 "-20.48~20.45 (m/s²)" 29 "-20.48~20.45 (m/s²)" 30 "-20.48~20.45 (m/s²)" 31 "-20.48~20.45 (m/s²)" 32 "-20.48~20.45 (m/s²)" 33 "-20.48~20.45 (m/s²)" 34 "-20.48~20.45 (m/s²)" 35 "-20.48~20.45 (m/s²)" 36 "-20.48~20.45 (m/s²)" 37 "-20.48~20.45 (m/s²)" 38 "-20.48~20.45 (m/s²)" 39 "-20.48~20.45 (m/s²)" 40 "-20.48~20.45 (m/s²)" 41 "-20.48~20.45 (m/s²)" 42 "-20.48~20.45 (m/s²)" 43 "-20.48~20.45 (m/s²)" 44 "-20.48~20.45 (m/s²)" 45 "-20.48~20.45 (m/s²)" 46 "-20.48~20.45 (m/s²)" 47 "-20.48~20.45 (m/s²)" 48 "-20.48~20.45 (m/s²)" 49 "-20.48~20.45 (m/s²)" 50 "-20.48~20.45 (m/s²)" 51 "-20.48~20.45 (m/s²)" 52 "-20.48~20.45 (m/s²)" 53 "-20.48~20.45 (m/s²)" 54 "-20.48~20.45 (m/s²)" 55 "-20.48~20.45 (m/s²)" 56 "-20.48~20.45 (m/s²)" 57 "-20.48~20.45 (m/s²)" 58 "-20.48~20.45 (m/s²)" 59 "-20.48~20.45 (m/s²)" 60 "-20.48~20.45 (m/s²)" 61 "-20.48~20.45 (m/s²)" 62 "-20.48~20.45 (m/s²)" 63 "-20.48~20.45 (m/s²)" 64 "-20.48~20.45 (m/s²)" 65 "-20.48~20.45 (m/s²)" 66 "-20.48~20.45 (m/s²)" 67 "-20.48~20.45 (m/s²)" 68 "-20.48~20.45 (m/s²)" 69 "-20.48~20.45 (m/s²)" 70 "-20.48~20.45 (m/s²)" 71 "-20.48~20.45 (m/s²)" 72 "-20.48~20.45 (m/s²)" 73 "-20.48~20.45 (m/s²)" 74 "-20.48~20.45 (m/s²)" 75 "-20.48~20.45 (m/s²)" 76 "-20.48~20.45 (m/s²)" 77 "-20.48~20.45 (m/s²)" 78 "-20.48~20.45 (m/s²)" 79 "-20.48~20.45 (m/s²)" 80 "-20.48~20.45 (m/s²)" 81 "-20.48~20.45 (m/s²)" 82 "-20.48~20.45 (m/s²)" 83 "-20.48~20.45 (m/s²)" 84 "-20.48~20.45 (m/s²)" 85 "-20.48~20.45 (m/s²)" 86 "-20.48~20.45 (m/s²)" 87 "-20.48~20.45 (m/s²)" 88 "-20.48~20.45 (m/s²)" 89 "-20.48~20.45 (m/s²)" 90 "-20.48~20.45 (m/s²)" 91 "-20.48~20.45 (m/s²)" 92 "-20.48~20.45 (m/s²)" 93 "-20.48~20.45 (m/s²)" 94 "-20.48~20.45 (m/s²)" 95 "-20.48~20.45 (m/s²)" 96 "-20.48~20.45 (m/s²)" 97 "-20.48~20.45 (m/s²)" 98 "-20.48~20.45 (m/s²)" 99 "-20.48~20.45 (m/s²)" 100 "-20.48~20.45 (m/s²)" 101 "-20.48~20.45 (m/s²)" 102 "-20.48~20.45 (m/s²)" 103 "-20.48~20.45 (m/s²)" 104 "-20.48~20.45 (m/s²)" 105 "-20.48~20.45 (m/s²)" 106 "-20.48~20.45 (m/s²)" 107 "-20.48~20.45 (m/s²)" 108 "-20.48~20.45 (m/s²)" 109 "-20.48~20.45 (m/s²)" 110 "-20.48~20.45 (m/s²)" 111 "-20.48~20.45 (m/s²)" 112 "-20.48~20.45 (m/s²)" 113 "-20.48~20.45 (m/s²)" 114 "-20.48~20.45 (m/s²)" 115 "-20.48~20.45 (m/s²)" 116 "-20.48~20.45 (m/s²)" 117 "-20.48~20.45 (m/s²)" 118 "-20.48~20.45 (m/s²)" 119 "-20.48~20.45 (m/s²)" 120 "-20.48~20.45 (m/s²)" 121 "-20.48~20.45 (m/s²)" 122 "-20.48~20.45 (m/s²)" 123 "-20.48~20.45 (m/s²)" 124 "-20.48~20.45 (m/s²)" 125 "-20.48~20.45 (m/s²)" 126 "-20.48~20.45 (m/s²)" 127 "-20.48~20.45 (m/s²)" 128 "-20.48~20.45 (m/s²)" 129 "-20.48~20.45 (m/s²)" 130 "-20.48~20.45 (m/s²)" 131 "-20.48~20.45 (m/s²)" 132 "-20.48~20.45 (m/s²)" 133 "-20.48~20.45 (m/s²)" 134 "-20.48~20.45 (m/s²)" 135 "-20.48~20.45 (m/s²)" 136 "-20.48~20.45 (m/s²)" 137 "-20.48~20.45 (m/s²)" 138 "-20.48~20.45 (m/s²)" 139 "-20.48~20.45 (m/s²)" 140 "-20.48~20.45 (m/s²)" 141 "-20.48~20.45 (m/s²)" 142 "-20.48~20.45 (m/s²)" 143 "-20.48~20.45 (m/s²)" 144 "-20.48~20.45 (m/s²)" 145 "-20.48~20.45 (m/s²)" 146 "-20.48~20.45 (m/s²)" 147 "-20.48~20.45 (m/s²)" 148 "-20.48~20.45 (m/s²)" 149 "-20.48~20.45 (m/s²)" 150 "-20.48~20.45 (m/s²)" 151 "-20.48~20.45 (m/s²)" 152 "-20.48~20.45 (m/s²)" 153 "-20.48~20.45 (m/s²)" 154 "-20.48~20.45 (m/s²)" 155 "-20.48~20.45 (m/s²)" 156 "-20.48~20.45 (m/s²)" 157 "-20.48~20.45 (m/s²)" 158 "-20.48~20.45 (m/s²)" 159 "-20.48~20.45 (m/s²)" 160 "-20.48~20.45 (m/s²)" 161 "-20.48~20.45 (m/s²)" 162 "-20.48~20.45 (m/s²)" 163 "-20.48~20.45 (m/s²)" 164 "-20.48~20.45 (m/s²)" 165 "-20.48~20.45 (m/s²)" 166 "-20.48~20.45 (m/s²)" 167 "-20.48~20.45 (m/s²)" 168 "-20.48~20.45 (m/s²)" 169 "-20.48~20.45 (m/s²)" 170 "-20.48~20.45 (m/s²)" 171 "-20.48~20.45 (m/s²)" 172 "-20.48~20.45 (m/s²)" 173 "-20.48~20.45 (m/s²)" 174 "-20.48~20.45 (m/s²)" 175 "-20.48~20.45 (m/s²)" 176 "-20.48~20.45 (m/s²)" 177 "-20.48~20.45 (m/s²)" 178 "-20.48~20.45 (m/s²)" 179 "-20.48~20.45 (m/s²)" 180 "-20.48~20.45 (m/s²)" 181 "-20.48~20.45 (m/s²)" 182 "-20.48~20.45 (m/s²)" 183 "-20.48~20.45 (m/s²)" 184 "-20.48~20.45 (m/s²)" 185 "-20.48~20.45 (m/s²)" 186 "-20.48~20.45 (m/s²)" 187 "-20.48~20.45 (m/s²)" 188 "-20.48~20.45 (m/s²)" 189 "-20.48~20.45 (m/s²)" 190 "-20.48~20.45 (m/s²)" 191 "-20.48~20.45 (m/s²)" 192 "-20.48~20.45 (m/s²)" 193 "-20.48~20.45 (m/s²)" 194 "-20.48~20.45 (m/s²)" 195 "-20.48~20.45 (m/s²)" 196 "-20.48~20.45 (m/s²)" 197 "-20.48~20.45 (m/s²)" 198 "-20.48~20.45 (m/s²)" 199 "-20.48~20.45 (m/s²)" 200 "-20.48~20.45 (m/s²)" 201 "-20.48~20.45 (m/s²)" 202 "-20.48~20.45 (m/s²)" 203 "-20.48~20.45 (m/s²)" 204 "-20.48~20.45 (m/s²)" 205 "-20.48~20.45 (m/s²)" 206 "-20.48~20.45 (m/s²)" 207 "-20.48~20.45 (m/s²)" 208 "-20.48~20.45 (m/s²)" 209 "-20.48~20.45 (m/s²)" 210 "-20.48~20.45 (m/s²)" 211 "-20.48~20.45 (m/s²)" 212 "-20.48~20.45 (m/s²)" 213 "-20.48~20.45 (m/s²)" 214 "-20.48~20.45 (m/s²)" 215 "-20.48~20.45 (m/s²)" 216 "-20.48~20.45 (m/s²)" 217 "-20.48~20.45 (m/s²)" 218 "-20.48~20.45 (m/s²)" 219 "-20.48~20.45 (m/s²)" 220 "-20.48~20.45 (m/s²)" 221 "-20.48~20.45 (m/s²)" 222 "-20.48~20.45 (m/s²)" 223 "-20.48~20.45 (m/s²)" 224 "-20.48~20.45 (m/s²)" 225 "-20.48~20.45 (m/s²)" 226 "-20.48~20.45 (m/s²)" 227 "-20.48~20.45 (m/s²)" 228 "-20.48~20.45 (m/s²)" 229 "-20.48~20.45 (m/s²)" 230 "-20.48~20.45 (m/s²)" 231 "-20.48~20.45 (m/s²)" 232 "-20.48~20.45 (m/s²)" 233 "-20.48~20.45 (m/s²)" 234 "-20.48~20.45 (m/s²)" 235 "-20.48~20.45 (m/s²)" 236 "-20.48~20.45 (m/s²)" 237 "-20.48~20.45 (m/s²)" 238 "-20.48~20.45 (m/s²)" 239 "-20.48~20.45 (m/s²)" 240 "-20.48~20.45 (m/s²)" 241 "-20.48~20.45 (m/s²)" 242 "-20.48~20.45 (m/s²)" 243 "-20.48~20.45 (m/s²)" 244 "-20.48~20.45 (m/s²)" 245 "-20.48~20.45 (m/s²)" 246 "-20.48~20.45 (m/s²)" 247 "-20.48~20.45 (m/s²)" 248 "-20.48~20.45 (m/s²)" 249 "-20.48~20.45 (m/s²)" 250 "-20.48~20.45 (m/s²)" 251 "-20.48~20.45 (m/s²)" 252 "-20.48~20.45 (m/s²)" 253 "-20.48~20.45 (m/s²)" 254 "-20.48~20.45 (m/s²)" 255 "-20.48~20.45 (m/s²)" 256 "-20.48~20.45 (m/s²)" 257 "-20.48~20.45 (m/s²)" 258 "-20.48~20.45 (m/s²)" 259 "-20.48~20.45 (m/s²)" 260 "-20.48~20.45 (m/s²)" 261 "-20.48~20.45 (m/s²)" 262 "-20.48~20.45 (m/s²)" 263 "-20.48~20.45 (m/s²)" 264 "-20.48~20.45 (m/s²)" 265 "-20.48~20.45 (m/s²)" 266 "-20.48~20.45 (m/s²)" 267 "-20.48~20.45 (m/s²)" 268 "-20.48~20.45 (m/s²)" 269 "-20.48~20.45 (m/s²)" 270 "-20.48~20.45 (m/s²)" 271 "-20.48~20.45 (m/s²)" 272 "-20.48~20.45 (m/s²)" 273 "-20.48~20.45 (m/s²)" 274 "-20.48~20.45 (m/s²)" 275 "-20.48~20.45 (m/s²)" 276 "-20.48~20.45 (m/s²)" 277 "-20.48~20.45 (m/s²)" 278 "-20.48~20.45 (m/s²)" 279 "-20.48~20.45 (m/s²)" 280 "-20.48~20.45 (m/s²)" 281 "-20.48~20.45 (m/s²)" 282 "-20.48~20.45 (m/s²)" 283 "-20.48~20.45 (m/s²)" 284 "-20.48~20.45 (m/s²)" 285 "-20.48~20.45 (m/s²)" 286 "-20.48~20.45 (m/s²)" 287 "-20.48~20.45 (m/s²)" 288 "-20.48~20.45 (m/s²)" 289 "-20.48~20.45 (m/s²)" 290 "-20.48~20.45 (m/s²)" 291 "-20.48~20.45 (m/s²)" 292 "-20.48~20.45 (m/s²)" 293 "-20.48~20.45 (m/s²)" 294 "-20.48~20.45 (m/s²)" 295 "-20.48~20.45 (m/s²)" 296 "-20.48~20.45 (m/s²)" 297 "-20.48~20.45 (m/s²)" 298 "-20.48~20.45 (m/s²)" 299 "-20.48~20.45 (m/s²)" 300 "-20.48~20.45 (m/s²)" 301 "-20.48~20.45 (m/s²)" 302 "-20.48~20.45 (m/s²)" 303 "-20.48~20.45 (m/s²)" 304 "-20.48~20.45 (m/s²)" 305 "-20.48~20.45 (m/s²)" 306 "-20.48~20.45 (m/s²)" 307 "-20.48~20.45 (m/s²)" 308 "-20.48~20.45 (m/s²)" 309 "-20.48~20.45 (m/s²)" 310 "-20.48~20.45 (m/s²)" 311 "-20.48~20.45 (m/s²)" 312 "-20.48~20.45 (m/s²)" 313 "-20.48~20.45 (m/s²)" 314 "-20.48~20.45 (m/s²)" 315 "-20.48~20.45 (m/s²)" 316 "-20.48~20.45 (m/s²)" 317 "-20.48~20.45 (m/s²)" 318 "-20.48~20.45 (m/s²)" 319 "-20.48~20.45 (m/s²)" 320 "-20.48~20.45 (m/s²)" 321 "-20.48~20.45 (m/s²)" 322 "-20.48~20.45 (m/s²)" 323 "-20.48~20.45 (m/s²)" 324 "-20.48~20.45 (m/s²)" 325 "-20.48~20.45 (m/s²)" 326 "-20.48~20.45 (m/s²)" 327 "-20.48~20.45 (m/s²)" 328 "-20.48~20.45 (m/s²)" 329 "-20.48~20.45 (m/s²)" 330 "-20.48~20.45 (m/s²)" 331 "-20.48~20.45 (m/s²)" 332 "-20.48~20.45 (m/s²)" 333 "-20.48~20.45 (m/s²)" 334 "-20.48~20.45 (m/s²)" 335 "-20.48~20.45 (m/s²)" 336 "-20.48~20.45 (m/s²)" 337 "-20.48~20.45 (m/s²)" 338 "-20.48~20.45 (m/s²)" 339 "-20.48~20.45 (m/s²)" 340 "-20.48~20.45 (m/s²)" 341 "-20.48~20.45 (m/s²)" 342 "-20.48~20.45 (m/s²)" 343 "-20.48~20.45 (m/s²)" 344 "-20.48~20.45 (m/s²)" 345 "-20.48~20.45 (m/s²)" 346 "-20.48~20.45 (m/s²)" 347 "-20.48~20.45 (m/s²)" 348 "-20.48~20.45 (m/s²)" 349 "-20.48~20.45 (m/s²)" 350 "-20.48~20.45 (m/s²)" 351 "-20.48~20.45 (m/s²)" 352 "-20.48~20.45 (m/s²)" 353 "-20.48~20.45 (m/s²)" 354 "-20.48~20.45 (m/s²)" 355 "-20.48~20.45 (m/s²)" 356 "-20.48~20.45 (m/s²)" 357 "-20.48~20.45 (m/s²)" 358 "-20.48~20.45 (m/s²)" 359 "-20.48~20.45 (m/s²)" 360 "-20.48~20.45 (m/s²)" 361 "-20.48~20.45 (m/s²)" 362 "-20.48~20.45 (m/s²)" 363 "-20.48~20.45 (m/s²)" 364 "-20.48~20.45 (m/s²)" 365 "-20.48~20.45 (m/s²)" 366 "-20.48~20.45 (m/s²)" 367 "-20.48~20.45 (m/s²)" 368 "-20.48~20.45 (m/s²)" 369 "-20.48~20.45 (m/s²)" 370 "-20.48~20.45 (m/s²)" 371 "-20.48~20.45 (m/s²)" 372 "-20.48~20.45 (m/s²)" 373 "-20.48~20.45 (m/s²)" 374 "-20.48~20.45 (m/s²)" 375 "-20.48~20.45 (m/s²)" 376 "-20.48~20.45 (m/s²)" 377 "-20.48~20.45 (m/s²)" 378 "-20.48~20.45 (m/s²)" 379 "-20.48~20.45 (m/s²)" 380 "-20.48~20.45 (m/s²)" 381 "-20.48~20.45 (m/s²)" 382 "-20.48~20.45 (m/s²)" 383 "-20.48~20.45 (m/s²)" 384 "-20.48~20.45 (m/s²)" 385 "-20.48~20.45 (m/s²)" 386 "-20.48~20.45 (m/s²)" 387 "-20.48~20.45 (m/s²)" 388 "-20.48~20.45 (m/s²)" 389 "-20.48~20.45 (m/s²)" 390 "-20.48~20.45 (m/s²)" 391 "-20.48~20.45 (m/s²)" 392 "-20.48~20.45 (m/s²)" 393 "-20.48~20.45 (m/s²)" 394 "-20.48~20.45 (m/s²)" 395 "-20.48~20.45 (m/s²)" 396 "-20.48~20.45 (m/s²)" 397 "-20.48~20.45 (m/s²)" 398 "-20.48~20.45 (m/s²)" 399 "-20.48~20.45 (m/s²)" 400 "-20.48~20.45 (m/s²)" 401 "-20.48~20.45 (m/s²)" 402 "-20.48~20.45 (m/s²)" 403 "-20.48~20.45 (m/s²)" 404 "-20.48~20.45 (m/s²)" 405 "-20.48~20.45 (m/s²)" 406 "-20.48~20.45 (m/s²)" 407 "-20.48~20.45 (m/s²)" 408 "-20.48~20.45 (m/s²)" 409 "-20.48~20.45 (m/s²)" 410 "-20.48~20.45 (m/s²)" 411 "-20.48~20.45 (m/s²)" 412 "-20.48~20.45 (m/s²)" 413 "-20.48~20.45 (m/s²)" 414 "-20.48~20.45 (m/s²)" 415 "-20.48~20.45 (m/s²)" 416 "-20.48~20.45 (m/s²)" 417 "-20.48~20.45 (m/s²)" 418 "-20.48~20.45 (m/s²)" 419 "-20.48~20.45 (m/s²)" 420 "-20.48~20.45 (m/s²)" 421 "-20.48~20.45 (m/s²)" 422 "-20.48~20.45 (m/s²)" 423 "-20.48~20.45 (m/s²)" 424 "-20.48~20.45 (m/s²)" 425 "-20.48~20.45 (m/s²)" 426 "-20.48~20.45 (m/s²)" 427 "-20.48~20.45 (m/s²)" 428 "-20.48~20.45 (m/s²)" 429 "-20.48~20.45 (m/s²)" 430 "-20.48~20.45 (m/s²)" 431 "-20.48~20.45 (m/s²)" 432 "-20.48~20.45 (m/s²)" 433 "-20.48~20.45 (m/s²)" 434 "-20.48~20.45 (m/s²)" 435 "-20.48~20.45 (m/s²)" 436 "-20.48~20.45 (m/s²)" 437 "-20.48~20.45 (m/s²)" 438 "-20.48~20.45 (m/s²)" 439 "-20.48~20.45 (m/s²)" 440 "-20.48~20.45 (m/s²)" 441 "-20.48~20.45 (m/s²)" 442 "-20.48~20.45 (m/s²)" 443 "-20.48~20.45 (m/s²)" 444 "-20.48~20.45 (m/s²)" 445 "-20.48~20.45 (m/s²)" 446 "-20.48~20.45 (m/s²)" 447 "-20.48~20.45 (m/s²)" 448 "-20.48~20.45 (m/s²)" 449 "-20.48~20.45 (m/s²)" 450 "-20.48~20.45 (m/s²)" 451 "-20.48~20.45 (m/s²)" 452 "-20.48~20.45 (m/s²)" 453 "-20.48~20.45 (m/s²)" 454 "-20.48~20.45 (m/s²)" 455 "-20.48~20.45 (m/s²)" 456 "-20.48~20.45 (m/s²)" 457 "-20.48~20.45 (m/s²)" 458 "-20.48~20.45 (m/s²)" 459 "-20.48~20.45 (m/s²)" 460 "-20.48~20.45 (m/s²)" 461 "-20.48~20.45 (m/s²)" 462 "-20.48~20.45 (m/s²)" 463 "-20.48~20.45 (m/s²)" 464 "-20.48~20.45 (m/s²)" 465 "-20.48~20.45 (m/s²)" 466 "-20.48~20.45 (m/s²)" 467 "-20.48~20.45 (m/s²)" 468 "-20.48~20.45 (m/s²)" 469 "-20.48~20.45 (m/s²)" 470 "-20.48~20.45 (m/s²)" 471 "-20.48~20.45 (m/s²)" 472 "-20.48~20.45 (m/s²)" 473 "-20.48~20.45 (m/s²)" 474 "-20.48~20.45 (m/s²)" 475 "-20.48~20.45 (m/s²)" 476 "-20.48~20.45 (m/s²)" 477 "-20.48~20.45 (m/s²)" 478 "-20.48~20.45 (m/s²)" 479 "-20.48~20.45 (m/s²)" 480 "-20.48~20.45 (m/s²)" 481 "-20.48~20.45 (m/s²)" 482 "-20.48~20.45 (m/s²)" 483 "-20.48~20.45 (m/s²)" 484 "-20.48~20.45 (m/s²)" 485 "-20.48~20.45 (m/s²)" 486 "-20.48~20.45 (m/s²)" 487 "-20.48~20.45 (m/s²)" 488 "-20.48~20.45 (m/s²)" 489 "-20.48~20.45 (m/s²)" 490 "-20.48~20.45 (m/s²)" 491 "-20.48~20.45 (m/s²)" 492 "-20.48~20.45 (m/s²)" 493 "-20.48~20.45 (m/s²)" 494 "-20.48~20.45 (m/s²)" 495 "-20.48~20.45 (m/s²)" 496 "-20.48~20.45 (m/s²)" 497 "-20.48~20.45 (m/s²)" 498 "-20.48~20.45 (m/s²)" 499 "-20.48~20.45 (m/s²)" 500 "-20.48~20.45 (m/s²)" 501 "-20.48~20.45 (m/s²)" 502 "-20.48~20.45 (m/s²)" 503 "-20.48~20.45 (m/s²)" 504 "-20.48~20.45 (m/s²)" 505 "-20.48~20.45 (m/s²)" 506 "-20.48~20.45 (m/s²)" 507 "-20.48~20.45 (m/s²)" 508 "-20.48~20.45 (m/s²)" 509 "-20.48~20.45 (m/s²)" 510 "-20.48~20.45 (m/s²)" 511 "-20.48~20.45 (m/s²)" 512 "-20.48~20.45 (m/s²)" 513 "-20.48~20.45 (m/s²)" 514 "-20.48~20.45 (m/s²)" 515 "-20.48~20.45 (m/s²)" 516 "-20.48~20.45 (m/s²)" 517 "-20.48~20.45 (m/s²)" 518 "-20.48~20.45 (m/s²)" 519 "-20.48~20.45 (m/s²)" 520 "-20.48~20.45 (m/s²)" 521 "-20.48~20.45 (m/s²)" 522 "-20.48~20.45 (m/s²)" 523 "-20.48~20.45 (m/s²)" 524 "-20.48~20.45 (m/s²)" 525 "-20.48~20.45 (m/s²)" 526 "-20.48~20.45 (m/s²)" 527 "-20.48~20.45 (m/s²)" 528 "-20.48~20.45 (m/s²)" 529 "-20.48~20.45 (m/s²)" 530 "-20.48~20.45 (m/s²)" 531 "-20.48~20.45 (m/s²)" 532 "-20.48~20.45 (m/s²)" 533 "-20.48~20.45 (m/s²)" 534 "-20.48~20.45 (m/s²)" 535 "-20.48~20.45 (m/s²)" 536 "-20.48~20.45 (m/s²)" 537 "-20.48~20.45 (m/s²)" 538 "-20.48~20.45 (m/s²)" 539 "-20.48~20.45 (m/s²)" 540 "-20.48~20.45 (m/s²)" 541 "-20.48~20.45 (m/s²)" 542 "-20.48~20.45 (m/s²)" 543 "-20.48~20.45 (m/s²)" 544 "-20.48~20.45 (m/s²)" 545 "-20.48~20.45 (m/s²)" 546 "-20.48~20.45 (m/s²)" 547 "-20.48~20.45 (m/s²)" 548 "-20.48~20.45 (m/s²)" 549 "-20.48~20.45 (m/s²)" 550 "-20.48~20.45 (m/s²)" 551 "-20.48~20.45 (m/s²)" 552 "-20.48~20.45 (m/s²)" 553 "-20.48~20.45 (m/s²)" 554 "-20.48~20.45 (m/s²)" 555 "-20.48~20.45 (m/s²)" 556 "-20.48~20.45 (m/s²)" 557 "-20.48~20.45 (m/s²)" 558 "-20.48~20.45 (m/s²)" 559 "-20.48~20.45 (m/s²)" 560 "-20.48~20.45 (m/s²)" 561 "-20.48~20.45 (m/s²)" 562 "-20.48~20.45 (m/s²)" 563 "-20.48~20.45 (m/s²)" 564 "-20.48~20.45 (m/s²)" 565 "-20.48~20.45 (m/s²)" 566 "-20.48~20.45 (m/s²)" 567 "-20.48~20.45 (m/s²)" 568 "-20.48~20.45 (m/s²)" 569 "-20.48~20.45 (m/s²)" 570 "-20.48~20.45 (m/s²)" 571 "-20.48~20.45 (m/s²)" 572 "-20.48~20.45 (m/s²)" 573 "-20.48~20.45 (m/s²)" 574 "-20.48~20.45 (m/s²)" 575 "-20.48~20.45 (m/s²)" 576 "-20.48~20.45 (m/s²)" 577 "-20.48~20.45 (m/s²)" 578 "-20.48~20.45 (m/s²)" 579 "-20.48~20.45 (m/s²)" 580 "-20.48~20.45 (m/s²)" 581 "-20.48~20.45 (m/s²)" 582 "-20.48~20.45 (m/s²)" 583 "-20.48~20.45 (m/s²)" 584 "-20.48~20.45 (m/s²)" 585 "-20.48~20.45 (m/s²)" 586 "-20.48~20.45 (m/s²)" 587 "-20.48~20.45 (m/s²)" 588 "-20.48~20.45 (m/s²)" 589 "-20.48~20.45 (m/s²)" 590 "-20.48~20.45 (m/s²)" 591 "-20.48~20.45 (m/s²)" 592 "-20.48~20.45 (m/s²)" 593 "-20.48~20.45 (m/s²)" 594 "-20.48~20.45 (m/s²)" 595 "-20.48~20.45 (m/s²)" 596 "-20.48~20.45 (m/s²)" 597 "-20.48~20.45 (m/s²)" 598 "-20.48~20.45 (m/s²)" 599 "-20.48~20.45 (m/s²)" 600 "-20.48~20.45 (m/s²)" 601 "-20.48~20.45 (m/s²)" 602 "-20.48~20.45 (m/s²)" 603 "-20.48~20.45 (m/s²)" 604 "-20.48~20.45 (m/s²)" 605 "-20.48~20.45 (m/s²)" 606 "-20.48~20.45 (m/s²)" 607 "-20.48~20.45 (m/s²)" 608 "-20.48~20.45 (m/s²)" 609 "-20.48~20.45 (m/s²)" 610 "-20.48~20.45 (m/s²)" 611 "-20.48~20.45 (m/s²)" 612 "-20.48~20.45 (m/s²)" 613 "-20.48~20.45 (m/s²)" 614 "-20.48~20.45 (m/s²)" 615 "-20.48~20.45 (m/s²)" 616 "-20.48~20.45 (m/s²)" 617 "-20.48~20.45 (m/s²)" 618 "-20.48~20.45 (m/s²)" 619 "-20.48~20.45 (m/s²)" 620 "-20.48~20.45 (m/s²)" 621 "-20.48~20.45 (m/s²)" 622 "-20.48~20.45 (m/s²)" 623 "-20.48~20.45 (m/s²)" 624 "-20.48~20.45 (m/s²)" 625 "-20.48~20.45 (m/s²)" 626 "-20.48~20.45 (m/s²)" 627 "-20.48~20.45 (m/s²)" 628 "-20.48~20.45 (m/s²)" 629 "-20.48~20.45 (m/s²)" 630 "-20.48~20.45 (m/s²)" 631 "-20.48~20.45 (m/s²)" 632 "-20.48~20.45 (m/s²)" 633 "-20.48~20.45 (m/s²)" 634 "-20.48~20.45 (m/s²)" 635 "-20.48~20.45 (m/s²)" 636 "-20.48~20.45 (m/s²)" 637 "-20.48~20.45 (m/s²)" 638 "-20.48~20.45 (m/s²)" 639 "-20.48~20.45 (m/s²)" 640 "-20.48~20.45 (m/s²)" 641 "-20.48~20.45 (m/s²)" 642 "-20.48~20.45 (m/s²)" 643 "-20.48~20.45 (m/s²)" 644 "-20.48~20.45 (m/s²)" 645 "-20.48~20.45 (m/s²)" 646 "-20.48~20.45 (m/s²)" 647 "-20.48~20.45 (m/s²)" 648 "-20.48~20.45 (m/s²)" 649 "-20.48~20.45 (m/s²)" 650 "-20.48~20.45 (m/s²)" 651 "-20.48~20.45 (m/s²)" 652 "-20.48~20.45 (m/s²)" 653 "-20.48~20.45 (m/s²)" 654 "-20.48~20.45 (m/s²)" 655 "-20.48~20.45 (m/s²)" 656 "-20.48~20.45 (m/s²)" 657 "-20.48~20.45 (m/s²)" 658 "-20.48~20.45 (m/s²)" 659 "-20.48~20.45 (m/s²)" 660 "-20.48~20.45 (m/s²)" 661 "-20.48~20.45 (m/s²)" 662 "-20.48~20.45 (m/s²)" 663 "-20.48~20.45 (m/s²)" 664 "-20.48~20.45 (m/s²)" 665 "-20.48~20.45 (m/s²)" 666 "-20.48~20.45 (m/s²)" 667 "-20.48~20.45 (m/s²)" 668 "-20.48~20.45 (m/s²)" 669 "-20.48~20.45 (m/s²)" 670 "-20.48~20.45 (m/s²)" 671 "-20.48~20.45 (m/s²)" 672 "-20.48~20.45 (m/s²)" 673 "-20.48~20.45 (m/s²)" 674 "-20.48~20.45 (m/s²)" 675 "-20.48~20.45 (m/s²)" 676 "-20.48~20.45 (m/s²)" 677 "-20.48~20.45 (m/s²)" 678 "-20.48~20.45 (m/s²)" 679 "-20.48~20.45 (m/s²)" 680 "-20.48~20.45 (m/s²)" 681 "-20.48~20.45 (m/s²)" 682 "-20.48~20.45 (m/s²)" 683 "-20.48~20.45 (m/s²)" 684 "-20.48~20.45 (m/s²)" 685 "-20.48~20.45 (m/s²)" 686 "-20.48~20.45 (m/s²)" 687 "-20.48~20.45 (m/s²)" 688 "-20.48~20.45 (m/s²)" 689 "-20.48~20.45 (m/s²)" 690 "-20.48~20.45 (m/s²)" 691 "-20.48~20.45 (m/s²)" 692 "-20.48~20.45 (m/s²)" 693 "-20.48~20.45 (m/s²)" 694 "-20.48~20.45 (m/s²)" 695 "-20.48~20.45 (m/s²)" 696 "-20.48~20.45 (m/s²)" 697 "-20.48~20.45 (m/s²)" 698 "-20.48~20.45 (m/s²)" 699 "-20.48~20.45 (m/s²)" 700 "-20.48~20.45 (m/s²)" 701 "-20.48~20.45 (m/s²)" 702 "-20.48~20.45 (m/s²)" 703 "-20.48~20.45 (m/s²)" 704 "-20.48~20.45 (m/s²)" 705 "-20.48~20.45 (m/s²)" 706 "-20.48~20.45 (m/s²)" 707 "-20.48~20.45 (m/s²)" 708 "-20.48~20.45 (m/s²)" 709 "-20.48~20.45 (m/s²)" 710 "-20.48~20.45 (m/s²)" 711 "-20.48~20.45 (m/s²)" 712 "-20.48~20.45 (m/s²)" 713 "-20.48~20.45 (m/s²)" 714 "-20.48~20.45 (m/s²)" 715 "-20.48~20.45 (m/s²)" 716 "-20.48~20.45 (m/s²)" 717 "-20.48~20.45 (m/s²)" 718 "-20.48~20.45 (m/s²)" 719 "-20.48~20.45 (m/s²)" 720 "-20.48~20.45 (m/s²)" 721 "-20.48~20.45 (m/s²)" 722 "-20.48~20.45 (m/s²)" 723 "-20.48~20.45 (m/s²)" 724 "-20.48~20.45 (m/s²)" 725 "-20.48~20.45 (m/s²)" 726 "-20.48~20.45 (m/s²)" 727 "-20.48~20.45 (m/s²)" 728 "-20.48~20.45 (m/s²)" 729 "-20.48~20.45 (m/s²)" 730 "-20.48~20.45 (m/s²)" 731 "-20.48~20.45 (m/s²)" 732 "-20.48~20.45 (m/s²)" 733 "-20.48~20.45 (m/s²)" 734 "-20.48~20.45 (m/s²)" 735 "-20.48~20.45 (m/s²)" 736 "-20.48~20.45 (m/s²)" 737 "-20.48~20.45 (m/s²)" 738 "-20.48~20.45 (m/s²)" 739 "-20.48~20.45 (m/s²)" 740 "-20.48~20.45 (m/s²)" 741 "-20.48~20.45 (m/s²)" 742 "-20.48~20.45 (m/s²)" 743 "-20.48~20.45 (m/s²)" 744 "-20.48~20.45 (m/s²)" 745 "-20.48~20.45 (m/s²)" 746 "-20.48~20.45 (m/s²)" 747 "-20.48~20.45 (m/s²)" 748 "-20.48~20.45 (m/s²)" 749 "-20.48~20.45 (m/s²)" 750 "-20.48~20.45 (m/s²)" 751 "-20.48~20.45 (m/s²)" 752 "-20.48~20.45 (m/s²)" 753 "-20.48~20.45 (m/s²)" 754 "-20.48~20.45 (m/s²)" 755 "-20.48~20.45 (m/s²)" 756 "-20.48~20.45 (m/s²)" 757 "-20.48~20.45 (m/s²)" 758 "-20.48~20.45 (m/s²)" 759 "-20.48~20.45 (m/s²)" 760 "-20.48~20.45 (m/s²)" 761 "-20.48~20.45 (m/s²)" 762 "-20.48~20.45 (m/s²)" 763 "-20.48~20.45 (m/s²)" 764 "-20.48~20.45 (m/s²)" 765 "-20.48~20.45 (m/s²)" 766 "-20.48~20.45 (m/s²)" 767 "-20.48~20.45 (m/s²)" 768 "-20.48~20.45 (m/s²)" 769 "-20.48~20.45 (m/s²)" 770 "-20.48~20.45 (m/s²)" 771 "-20.48~20.45 (m/s²)" 772 "-20.48~20.45 (m/s²)" 773 "-20.48~20.45 (m/s²)" 774 "-20.48~20.45 (m/s²)" 775 "-20.48~20.45 (m/s²)" 776 "-20.48~20.45 (m/s²)" 777 "-20.48~20.45 (m/s²)" 778 "-20.48~20.45 (m/s²)" 779 "-20.48~20.45 (m/s²)" 780 "-20.48~20.45 (m/s²)" 781 "-20.48~20.45 (m/s²)" 782 "-20.48~20.45 (m/s²)" 783 "-20.48~20.45 (m/s²)" 784 "-20.48~20.45 (m/s²)" 785 "-20.48~20.45 (m/s²)" 786 "-20.48~20.45 (m/s²)" 787 "-20.48~20.45 (m/s²)" 788 "-20.48~20.45 (m/s²)" 789 "-20.48~20.45 (m/s²)" 790 "-20.48~20.45 (m/s²)" 791 "-20.48~20.45 (m/s²)" 792 "-20.48~20.45 (m/s²)" 793 "-20.48~20.45 (m/s²)" 794 "-20.48~20.45 (m/s²)" 795 "-20.48~20.45 (m/s²)" 796 "-20.48~20.45 (m/s²)" 797 "-20.48~20.45 (m/s²)" 798 "-20.48~20.45 (m/s²)" 799 "-20.48~20.45 (m/s²)" 800 "-20.48~20.45 (m/s²)" 801 "-20.48~20.45 (m/s²)" 802 "-20.48~20.45 (m/s²)" 803 "-20.48~20.45 (m/s²)" 804 "-20.48~20.45 (m/s²)" 805 "-20.48~20.45 (m/s²)" 806 "-20.48~20.45 (m/s²)" 807 "-20.48~20.45 (m/s²)" 808 "-20.48~20.45 (m/s²)" 809 "-20.48~20.45 (m/s²)" 810 "-20.48~20.45 (m/s²)" 811 "-20.48~20.45 (m/s²)" 812 "-20.48~20.45 (m/s²)" 813 "-20.48~20.45 (m/s²)" 814 "-20.48~20.45 (m/s²)" 815 "-20.48~20.45 (m/s²)" 816 "-20.48~20.45 (m/s²)" 817 "-20.48~20.45 (m/s²)" 818 "-20.48~20.45 (m/s²)" 819 "-20.48~20.45 (m/s²)" 820 "-20.48~20.45 (m/s²)" 821 "-20.48~20.45 (m/s²)" 822 "-20.48~20.45 (m/s²)" 823 "-20.48~20.45 (m/s²)" 824 "-20.48~20.45 (m/s²)" 825 "-20.48~20.45 (m/s²)" 826 "-20.48~20.45 (m/s²)" 827 "-20.48~20.45 (m/s²)" 828 "-20.48~20.45 (m/s²)" 829 "-20.48~20.45 (m/s²)" 830 "-20.48~20.45 (m/s²)" 831 "-20.48~20.45 (m/s²)" 832 "-20.48~20.45 (m/s²)" 833 "-20.48~20.45 (m/s²)" 834 "-20.48~20.45 (m/s²)" 835 "-20.48~20.45 (m/s²)" 836 "-20.48~20.45 (m/s²)" 837 "-20.48~20.45 (m/s²)" 838 "-20.48~20.45 (m/s²)" 839 "-20.48~20.45 (m/s²)" 840 "-20.48~20.45 (m/s²)" 841 "-20.48~20.45 (m/s²)" 842 "-20.48~20.45 (m/s²)" 843 "-20.48~20.45 (m/s²)" 844 "-20.48~20.45 (m/s²)" 845 "-20.48~20.45 (m/s²)" 846 "-20.48~20.45 (m/s²)" 847 "-20.48~20.45 (m/s²)" 848 "-20.48~20.45 (m/s²)" 849 "-20.48~20.45 (m/s²)" 850 "-20.48~20.45 (m/s²)" 851 "-20.48~20.45 (m/s²)" 852 "-20.48~20.45 (m/s²)" 853 "-20.48~20.45 (m/s²)" 854 "-20.48~20.45 (m/s²)" 855 "-20.48~20.45 (m/s²)" 856 "-20.48~20.45 (m/s²)" 857 "-20.48~20.45 (m/s²)" 858 "-20.48~20.45 (m/s²)" 859 "-20.48~20.45 (m/s²)" 860 "-20.48~20.45 (m/s²)" 861 "-20.48~20.45 (m/s²)" 862 "-20.48~20.45 (m/s²)" 863 "-20.48~20.45 (m/s²)" 864 "-20.48~20.45 (m/s²)" 865 "-20.48~20.45 (m/s²)" 866 "-20.48~20.45 (m/s²)" 867 "-20.48~20.45 (m/s²)" 868 "-20.48~20.45 (m/s²)" 869 "-20.48~20.45 (m/s²)" 870 "-20.48~20.45 (m/s²)" 871 "-20.48~20.45 (m/s²)" 872 "-20.48~20.45 (m/s²)" 873 "-20.48~20.45 (m/s²)" 874 "-20.48~20.45 (m/s²)" 875 "-20.48~20.45 (m/s²)" 876 "-20.48~20.45 (m/s²)" 877 "-20.48~20.45 (m/s²)" 878 "-20.48~20.45 (m/s²)" 879 "-20.48~20.45 (m/s²)" 880 "-20.48~20.45 (m/s²)" 881 "-20.48~20.45 (m/s²)" 882 "-20.48~20.45 (m/s²)" 883 "-20.48~20.45 (m/s²)" 884 "-20.48~20.45 (m/s²)" 885 "-20.48~20.45 (m/s²)" 886 "-20.48~20.45 (m/s²)" 887 "-20.48~20.45 (m/s²)" 888 "-20.48~20.45 (m/s²)" 889 "-20.48~20.45 (m/s²)" 890 "-20.48~20.45 (m/s²)" 891 "-20.48~20.45 (m/s²)" 892 "-20.48~20.45 (m/s²)" 893 "-20.48~20.45 (m/s²)" 894 "-20.48~20.45 (m/s²)" 895 "-20.48~20.45 (m/s²)" 896 "-20.48~20.45 (m/s²)" 897 "-20.48~20.45 (m/s²)" 898 "-20.48~20.45 (m/s²)" 899 "-20.48~20.45 (m/s²)" 900 "-20.48~20.45 (m/s²)" 901 "-20.48~20.45 (m/s²)" 902 "-20.48~20.45 (m/s²)" 903 "-20.48~20.45 (m/s²)" 904 "-20.48~20.45 (m/s²)" 905 "-20.48~20.45 (m/s²)" 906 "-20.48~20.45 (m/s²)" 907 "-20.48~20.45 (m/s²)" 908 "-20.48~20.45 (m/s²)" 909 "-20.48~20.45 (m/s²)" 910 "-20.48~20.45 (m/s²)" 911 "-20.48~20.45 (m/s²)" 912 "-20.48~20.45 (m/s²)" 913 "-20.48~20.45 (m/s²)" 914 "-20.48~20.45 (m/s²)" 915 "-20.48~20.45 (m/s²)" 916 "-20.48~20.45 (m/s²)" 917 "-20.48~20.45 (m/s²)" 918 "-20.48~20.45 (m/s²)" 919 "-20.48~20.45 (m/s²)" 920 "-20.48~20.45 (m/s²)" 921 "-20.48~20.45 (m/s²)" 922 "-20.48~20.45 (m/s²)" 923 "-20.48~20.45 (m/s²)" 924 "-20.48~20.45 (m/s²)" 925 "-20.48~20.45 (m/s²)" 926 "-20.48~20.45 (m/s²)" 927 "-20.48~20.45 (m/s²)" 928 "-20.48~20.45 (m/s²)" 929 "-20.48~20.45 (m/s²)" 930 "-20.48~20.45 (m/s²)" 931 "-20.48~20.45 (m/s²)" 932 "-20.48~20.45 (m/s²)" 933 "-20.48~20.45 (m/s²)" 934 "-20.48~20.45 (m/s²)" 935 "-20.48~20.45 (m/s²)" 936 "-20.48~20.45 (m/s²)" 937 "-20.48~20.45 (m/s²)" 938 "-20.48~20.45 (m/s²)" 939 "-20.48~20.45 (m/s²)" 940 "-20.48~20.45 (m/s²)" 941 "-20.48~20.45 (m/s²)" 942 "-20.48~20.45 (m/s²)" 943 "-20.48~20.45 (m/s²)" 944 "-20.48~20.45 (m/s²)" 945 "-20.48~20.45 (m/s²)" 946 "-20.48~20.45 (m/s²)" 947 "-20.48~20.45 (m/s²)" 948 "-20.48~20.45 (m/s²)" 949 "-20.48~20.45 (m/s²)" 950 "-20.48~20.45 (m/s²)" 951 "-20.48~20.45 (m/s²)" 952 "-20.48~20.45 (m/s²)" 953 "-20.48~20.45 (m/s²)" 954 "-20.48~20.45 (m/s²)" 955 "-20.48~20.45 (m/s²)" 956 "-20.48~20.45 (m/s²)" 957 "-20.48~20.45 (m/s²)" 958 "-20.48~20.45 (m/s²)" 959 "-20.48~20.45 (m/s²)" 960 "-20.48~20.45 (m/s²)" 961 "-20.48~20.45 (m/s²)" 962 "-20.48~20.45 (m/s²)" 963 "-20.48~20.45 (m/s²)" 964 "-20.48~20.45 (m/s²)" 965 "-20.48~20.45 (m/s²)" 966 "-20.48~20.45 (m/s²)" 967 "-20.48~20.45 (m/s²)" 968 "-20.48~20.45 (m/s²)" 969 "-20.48~20.45 (m/s²)" 970 "-20.48~20.45 (m/s²)" 971 "-20.48~20.45 (m/s²)" 972 "-20.48~20.45 (m/s²)" 973 "-20.48~20.45 (m/s²)" 974 "-20.48~20.45 (m/s²)" 975 "-20.48~20.45 (m/s²)" 976 "-20.48~20.45 (m/s²)" 977 "-20.48~20.45 (m/s²)" 978 "-20.48~20.45 (m/s²)" 979 "-20.48~20.45 (m/s²)" 980 "-20.48~20.45 (m/s²)" 981 "-20.48~20.45 (m/s²)" 982 "-20.48~20.45 (m/s²)" 983 "-20.48~20.45 (m/s²)" 984 "-20.48~20.45 (m/s²)" 985 "-20.48~20.45 (m/s²)" 986 "-20.48~20.45 (m/s²)" 987 "-20.48~20.45 (m/s²)" 988 "-20.48~20.45 (m/s²)" 989 "-20.48~20.45 (m/s²)" 990 "-20.48~20.45 (m/s²)" 991 "-20.48~20.45 (m/s²)" 992 "-20.48~20.45 (m/s²)" 993 "-20.48~20.45 (m/s²)" 994 "-20.48~20.45 (m/s²)" 995 "-20.48~20.45 (m/s²)" 996 "-20.48~20.45 (m/s²)" 997 "-20.48~20.45 (m/s²)" 998 "-20.48~20.45 (m/s²)" 999 "-20.48~20.45 (m/s²)" 1000 "-20.48~20.45 (m/s²)" 1001 "-20.48~20.45 (m/s²)" 1002 "-20.48~20.45 (m/s²)" 1003 "-20.48~20.45 (m/s²)" 1004 "-20.48~20.45 (m/s²)" 1005 "-20.48~20.45 (m/s²)" 1006 "-20.48~20.45 (m/s²)" 1007 "-20.48~20.45 (m/s²)" 1008 "-20.48~20.45 (m/s²)" 1009 "-20.48~20.45 (m/s²)" 1010 "-20.48~20.45 (m/s²)" 1011 "-20.48~20.45 (m/s²)" 1012 "-20.48~20.45 (m/s²)" 1013 "-20.48~20.45 (m/s²)" 1014 "-20.48~20.45 (m/s²)" 1015 "-20.48~20.45 (m/s²)" 1016 "-20.48~20.45 (m/s²)" 1017 "-20.48~20.45 (m/s²)" 1018 "-20.48~20.45 (m/s²)" 1019 "-20.48~20.45 (m/s²)" 1020 "-20.48~20.45 (m/s²)" 1021 "-20.48~20.45 (m/s²)" 1022 "-20.48~20.45 (m/s²)" 1023 "-20.48~20.45 (m/s²)" 1024 "-20.48~20.45 (m/s²)" 1025 "-20.48~20.45 (m/s²)" 1026 "-20.48~20.45 (m/s²)" 1027 "-20.48~20.45 (m/s²)" 1028 "-20.48~20.45 (m/s²)" 1029 "-20.48~20.45 (m/s²)" 1030 "-20.48~20.45 (m/s²)" 1031 "-20.48~20.45 (m/s²)" 1032 "-20.48~20.45 (m/s²)" 1033 "-20.48~20.45 (m/s²)" 1034 "-20.48~20.45 (m/s²)" 1035 "-20.48~20.45 (m/s²)" 1036 "-20.48~20.45 (m/s²)" 1037 "-20.48~20.45 (m/s²)" 1038 "-20.48~20.45 (m/s²)" 1039 "-20.48~20.45 (m/s²)" 1040 "-20.48~20.45 (m/s²)" 1041 "-20.48~20.45 (m/s²)" 1042 "-20.48~20.45 (m/s²)" 1043 "-20.48~20.45 (m/s²)" 1044 "-20.48~20.45 (m/s²)" 1045 "-20.48~20.45 (m/s²)" 1046 "-20.48~20.45 (m/s²)" 1047 "-20.48~20.45 (m/s²)" 1048 "-20.48~20.45 (m/s²)" 1049 "-20.48~20.45 (m/s²)" 1050 "-20.48~20.45 (m/s²)" 1051 "-20.48~20.45 (m/s²)" 1052 "-20.48~20.45 (m/s²)" 1053 "-20.48~20.45 (m/s²)" 1054 "-20.48~20.45 (m/s²)" 1055 "-20.48~20.45 (m/s²)" 1056 "-20.48~20.45 (m/s²)" 1057 "-20.48~20.45 (m/s²)" 1058 "-20.48~20.45 (m/s²)" 1059 "-20.48~20.45 (m/s²)" 1060 "-20.48~20.45 (m/s²)" 1061 "-20.48~20.45 (m/s²)" 1062 "-20.48~20.45 (m/s²)" 1063 "-20.48~20.45 (m/s²)" 1064 "-20.48~20.45 (m/s²)" 1065 "-20.48~20.45 (m/s²)" 1066 "-20.48~20.45 (m/s²)" 1067 "-20.48~20.45 (m/s²)" 1068 "-20.48~20.45 (m/s²)" 1069 "-20.48~20.45 (m/s²)" 1070 "-20.48~20.45 (m/s²)" 1071 "-20.48~20.45 (m/s²)" 1072 "-20.48~20.45 (m/s²)" 1073 "-20.48~20.45 (m/s²)" 1074 "-20.48~20.45 (m/s²)" 1075 "-20.48~20.45 (m/s²)" 1076 "-20.48~20.45 (m/s²)" 1077 "-20.48~20.45 (m/s²)" 1078 "-20.48~20.45 (m/s²)" 1079 "-20.48~20.45 (m/s²)" 1080 "-20.48~20.45 (m/s²)" 1081 "-20.48~20.45 (m/s²)" 1082 "-20.48~20.45 (m/s²)" 1083 "-20.48~20.45 (m/s²)" 1084 "-20.48~20.45 (m/s²)" 1085 "-20.48~20.45 (m/s²)" 1086 "-20.48~20.45 (m/s²)" 1087 "-20.48~20.45 (m/s²)" 1088 "-20.48~20.45 (m/s²)" 1089 "-20.48~20.45 (m/s²)" 1090 "-20.48~20.45 (m/s²)" 1091 "-20.48~20.45 (m/s²)" 1092 "-20.48~20.45 (m/s²)" 1093 "-20.48~20.45 (m/s²)" 1094 "-20.48~20.45 (m/s²)" 1095 "-20.48~20.45 (m/s²)" 1096 "-20.48~20.45 (m/s²)" 1097 "-20.48~20.45 (m/s²)" 1098 "-20.48~20.45 (m/s²)" 1099 "-20.48~20.45 (m/s²)" 1100 "-20.48~20.45 (m/s²)" 1101 "-20.48~20.45 (m/s²)" 1102 "-20.48~20.45 (m/s²)" 1103 "-20.48~20.45 (m/s²)" 1104 "-20.48~20.45 (m/s²)" 1105 "-20.48~20.45 (m/s²)" 1106 "-20.48~20.45 (m/s²)" 1107 "-20.48~20.45 (m/s²)" 1108 "-20.48~20.45 (m/s²)" 1109 "-20.48~20.45 (m/s²)" 1110 "-20.48~20.45 (m/s²)" 1111 "-20.48~20.45 (m/s²)" 1112 "-20.48~20.45 (m/s²)" 1113 "-20.48~20.45 (m/s²)" 1114 "-20.48~20.45 (m/s²)" 1115 "-20.48~20.45 (m/s²)" 1116 "-20.48~20.45 (m/s²)" 1117 "-20.48~20.45 (m/s²)" 1118 "-20.48~20.45 (m/s²)" 1119 "-20.48~20.45 (m/s²)" 1120 "-20.48~20.45 (m/s²)" 1121 "-20.48~20.45 (m/s²)" 1122 "-20.48~20.45 (m/s²)" 1123 "-20.48~20.45 (m/s²)" 1124 "-20.48~20.45 (m/s²)" 1125 "-20.48~20.45 (m/s²)" 1126 "-20.48~20.45 (m/s²)" 1127 "-20.48~20.45 (m/s²)" 1128 "-20.48~20.45 (m/s²)" 1129 "-20.48~20.45 (m/s²)" 1130 "-20.48~20.45 (m/s²)" 1131 "-20.48~20.45 (m/s²)" 1132 "-20.48~20.45 (m/s²)" 1133 "-20.48~20.45 (m/s²)" 1134 "-20.48~20.45 (m/s²)" 1135 "-20.48~20.45 (m/s²)" 1136 "-20.48~20.45 (m/s²)" 1137 "-20.48~20.45 (m/s²)" 1138 "-20.48~20.45 (m/s²)" 1139 "-20.48~20.45 (m/s²)" 1140 "-20.48~20.45 (m/s²)" 1141 "-20.48~20.45 (m/s²)" 1142 "-20.48~20.45 (m/s²)" 1143 "-20.48~20.45 (m/s²)" 1144 "-20.48~20.45 (m/s²)" 1145 "-20.48~20.45 (m/s²)" 1146 "-20.48~20.45 (m/s²)" 1147 "-20.48~20.45 (m/s²)" 1148 "-20.48~20.45 (m/s²)" 1149 "-20.48~20.45 (m/s²)" 1150 "-20.48~20.45 (m/s²)" 1151 "-20.48~20.45 (m/s²)" 1152 "-20.48~20.45 (m/s²)" 1153 "-20.48~20.45 (m/s²)" 1154 "-20.48~20.45 (m/s²)" 1155 "-20.48~20.45 (m/s²)" 1156 "-20.48~20.45 (m/s²)" 1157 "-20.48~20.45 (m/s²)" 1158 "-20.48~20.45 (m/s²)" 1159 "-20.48~20.45 (m/s²)" 1160 "-20.48~20.45 (m/s²)" 1161 "-20.48~20.45 (m/s²)" 1162 "-20.48~20.45 (m/s²)" 1163 "-20.48~20.45 (m/s²)" 1164 "-20.48~20.45 (m/s²)" 1165 "-20.48~20.45 (m/s²)" 1166 "-20.48~20.45 (m/s²)" 1167 "-20.48~20.45 (m/s²)" 1168 "-20.48~20.45 (m/s²)" 1169 "-20.48~20.45 (m/s²)" 1170 "-20.48~20.45 (m/s²)" 1171 "-20.48~20.45 (m/s²)" 1172 "-20.48~20.45 (m/s²)" 1173 "-20.48~20.45 (m/s²)" 1174 "-20.48~20.45 (m/s²)" 1175 "-20.48~20.45 (m/s²)" 1176 "-20.48~20.45 (m/s²)" 1177 "-20.48~20.45 (m/s²)" 1178 "-20.48~20.45 (m/s²)" 1179 "-20.48~20.45 (m/s²)" 1180 "-20.48~20.45 (m/s²)" 1181 "-20.48~20.45 (m/s²)" 1182 "-20.48~20.45 (m/s²)" 1183 "-20.48~20.45 (m/s²)" 1184 "-20.48~20.45 (m/s²)" 1185 "-20.48~20.45 (m/s²)" 1186 "-20.48~20.45 (m/s²)" 1187 "-20.48~20.45 (m/s²)" 1188 "-20.48~20.45 (m/s²)" 1189 "-20.48~20.45 (m/s²)" 1190 "-20.48~20.45 (m/s²)" 1191 "-20.48~20.45 (m/s²)" 1192 "-20.48~20.45 (m/s²)" 1193 "-20.48~20.45 (m/s²)" 1194 "-20.48~20.45 (m/s²)" 1195 "-20.48~20.45 (m/s²)" 1196 "-20.48~20.45 (m/s²)" 1197 "-20.48~20.45 (m/s²)" 1198 "-20.48~20.45 (m/s²)" 1199 "-20.48~20.45 (m/s²)" 1200 "-20.48~20.45 (m/s²)" 1201 "-20.48~20.45 (m/s²)" 1202 "-20.48~20.45 (m/s²)" 1203 "-20.48~20.45 (m/s²)" 1204 "-20.48~20.45 (m/s²)" 1205 "-20.48~20.45 (m/s²)" 1206 "-20.48~20.45 (m/s²)" 1207 "-20.48~20.45 (m/s²)" 1208 "-20.48~20.45 (m/s²)" 1209 "-20.48~20.45 (m/s²)" 1210 "-20.48~20.45 (m/s²)" 1211 "-20.48~20.45 (m/s²)" 1212 "-20.48~20.45 (m/s²)" 1213 "-20.48~20.45 (m/s²)" 1214 "-20.48~20.45 (m/s²)" 1215 "-20.48~20.45 (m/s²)" 1216 "-20.48~20.45 (m/s²)" 1217 "-20.48~20.45 (m/s²)" 1218 "-20.48~20.45 (m/s²)" 1219 "-20.48~20.45 (m/s²)" 1220 "-20.48~20.45 (m/s²)" 1221 "-20.48~20.45 (m/s²)" 1222 "-20.48~20.45 (m/s²)" 1223 "-20.48~20.45 (m/s²)" 1224 "-20.48~20.45 (m/s²)" 1225 "-20.48~20.45 (m/s²)" 1226 "-20.48~20.45 (m/s²)" 1227 "-20.48~20.45 (m/s²)" 1228 "-20.48~20.45 (m/s²)" 1229 "-20.48~20.45 (m/s²)" 1230 "-20.48~20.45 (m/s²)" 1231 "-20.48~20.45 (m/s²)" 1232 "-20.48~20.45 (m/s²)" 1233 "-20.48~20.45 (m/s²)" 1234 "-20.48~20.45 (m/s²)" 1235 "-20.48~20.45 (m/s²)" 1236 "-20.48~20.45 (m/s²)" 1237 "-20.48~20.45 (m/s²)" 1238 "-20.48~20.45 (m/s²)" 1239 "-20.48~20.45 (m/s²)" 1240 "-20.48~20.45 (m/s²)" 1241 "-20.48~20.45 (m/s²)" 1242 "-20.48~20.45 (m/s²)" 1243 "-20.48~20.45 (m/s²)" 1244 "-20.48~20.45 (m/s²)" 1245 "-20.48~20.45 (m/s²)" 1246 "-20.48~20.45 (m/s²)" 1247 "-20.48~20.45 (m/s²)" 1248 "-20.48~20.45 (m/s²)" 1249 "-20.48~20.45 (m/s²)" 1250 "-20.48~20.45 (m/s²)" 1251 "-20.48~20.45 (m/s²)" 1252 "-20.48~20.45 (m/s²)" 1253 "-20.48~20.45 (m/s²)" 1254 "-20.48~20.45 (m/s²)" 1255 "-20.48~20.45 (m/s²)" 1256 "-20.48~20.45 (m/s²)" 1257 "-20.48~20.45 (m/s²)" 1258 "-20.48~20.45 (m/s²)" 1259 "-20.48~20.45 (m/s²)" 1260 "-20.48~20.45 (m/s²)" 1261 "-20.48~20.45 (m/s²)" 1262 "-20.48~20.45 (m/s²)" 1263 "-20.48~20.45 (m/s²)" 1264 "-20.48~20.45 (m/s²)" 1265 "-20.48~20.45 (m/s²)" 1266 "-20.48~20.45 (m/s²)" 1267 "-20.48~20.45 (m/s²)" 1268 "-20.48~20.45 (m/s²)" 1269 "-20.48~20.45 (m/s²)" 1270 "-20.48~20.45 (m/s²)" 1271 "-20.48~20.45 (m/s²)" 1272 "-20.48~20.45 (m/s²)" 1273 "-20.48~20.45 (m/s²)" 1274 "-20.48~20.45 (m/s²)" 1275 "-20.48~20.45 (m/s²)" 1276 "-20.48~20.45 (m/s²)" 1277 "-20.48~20.45 (m/s²)" 1278 "-20.48~20.45 (m/s²)" 1279 "-20.48~20.45 (m/s²)" 1280 "-20.48~20.45 (m/s²)" 1281 "-20.48~20.45 (m/s²)" 1282 "-20.48~20.45 (m/s²)" 1283 "-20.48~20.45 (m/s²)" 1284 "-20.48~20.45 (m/s²)" 1285 "-20.48~20.45 (m/s²)" 1286 "-20.48~20.45 (m/s²)" 1287 "-20.48~20.45 (m/s²)" 1288 "-20.48~20.45 (m/s²)" 1289 "-20.48~20.45 (m/s²)" 1290 "-20.48~20.45 (m/s²)" 1291 "-20.48~20.45 (m/s²)" 1292 "-20.48~20.45 (m/s²)" 1293 "-20.48~20.45 (m/s²)" 1294 "-20.48~20.45 (m/s²)" 1295 "-20.48~20.45 (m/s²)" 1296 "-20.48~20.45 (m/s²)" 1297 "-20.48~20.45 (m/s²)" 1298 "-20.48~20.45 (m/s²)" 1299 "-20.48~20.45 (m/s²)" 1300 "-20.48~20.45 (m/s²)" 1301 "-20.48~20.45 (m/s²)" 1302 "-20.48~20.45 (m/s²)" 1303 "-20.48~20.45 (m/s²)" 1304 "-20.48~20.45 (m/s²)" 1305 "-20.48~20.45 (m/s²)" 1306 "-20.48~20.45 (m/s²)" 1307 "-20.48~20.45 (m/s²)" 1308 "-20.48~20.45 (m/s²)" 1309 "-20.48~20.45 (m/s²)" 1310 "-20.48~20.45 (m/s²)" 1311 "-20.48~20.45 (m/s²)" 1312 "-20.48~20.45 (m/s²)" 1313 "-20.48~20.45 (m/s²)" 1314 "-20.48~20.45 (m/s²)" 1315 "-20.48~20.45 (m/s²)" 1316 "-20.48~20.45 (m/s²)" 1317 "-20.48~20.45 (m/s²)" 1318 "-20.48~20.45 (m/s²)" 1319 "-20.48~20.45 (m/s²)" 1320 "-20.48~20.45 (m/s²)" 1321 "-20.48~20.45 (m/s²)" 1322 "-20.48~20.45 (m/s²)" 1323 "-20.48~20.45 (m/s²)" 1324 "-20.48~20.45 (m/s²)" 1325 "-20.48~20.45 (m/s²)" 1326 "-20.48~20.45 (m/s²)" 1327 "-20.48~20.45 (m/s²)" 1328 "-20.48~20.45 (m/s²)" 1329 "-20.48~20.45 (m/s²)" 1330 "-20.48~20.45 (m/s²)" 1331 "-20.48~20.45 (m/s²)" 1332 "-20.48~20.45 (m/s²)" 1333 "-20.48~20.45 (m/s²)" 1334 "-20.48~20.45 (m/s²)" 1335 "-20.48~20.45 (m/s²)" 1336 "-20.48~20.45 (m/s²)" 1337 "-20.48~20.45 (m/s²)" 1338 "-20.48~20.45 (m/s²)" 1339 "-20.48~20.45 (m/s²)" 1340 "-20.48~20.45 (m/s²)" 1341 "-20.48~20.45 (m/s²)" 1342 "-20.48~20.45 (m/s²)" 1343 "-20.48~20.45 (m/s²)" 1344 "-20.48~20.45 (m/s²)" 1345 "-20.48~20.45 (m/s²)" 1346 "-20.48~20.45 (m/s²)" 1347 "-20.48~20.45 (m/s²)" 1348 "-20.48~20.45 (m/s²)" 1349 "-20.48~20.45 (m/s²)" 1350 "-20.48~20.45 (m/s²)" 1351 "-20.48~20.45 (m/s²)" 1352 "-20.48~20.45 (m/s²)" 1353 "-20.48~20.45 (m/s²)" 1354 "-20.48~20.45 (m/s²)" 1355 "-20.48~20.45 (m/s²)" 1356 "-20.48~20.45 (m/s²)" 1357 "-20.48~20.45 (m/s²)" 1358 "-20.48~20.45 (m/s²)" 1359 "-20.48~20.45 (m/s²)" 1360 "-20.48~20.45 (m/s²)" 1361 "-20.48~20.45 (m/s²)" 1362 "-20.48~20.45 (m/s²)" 1363 "-20.48~20.45 (m/s²)" 1364 "-20.48~20.45 (m/s²)" 1365 "-20.48~20.45 (m/s²)" 1366 "-20.48~20.45 (m/s²)" 1367 "-20.48~20.45 (m/s²)" 1368 "-20.48~20.45 (m/s²)" 1369 "-20.48~20.45 (m/s²)" 1370 "-20.48~20.45 (m/s²)" 1371 "-20.48~20.45 (m/s²)" 1372 "-20.48~20.45 (m/s²)" 1373 "-20.48~20.45 (m/s²)" 1374 "-20.48~20.45 (m/s²)" 1375 "-20.48~20.45 (m/s²)" 1376 "-20.48~20.45 (m/s²)" 1377 "-20.48~20.45 (m/s²)" 1378 "-20.48~20.45 (m/s²)" 1379 "-20.48~20.45 (m/s²)" 1380 "-20.48~20.45 (m/s²)" 1381 "-20.48~20.45 (m/s²)" 1382 "-20.48~20.45 (m/s²)" 1383 "-20.48~20.45 (m/s²)" 1384 "-20.48~20.45 (m/s²)" 1385 "-20.48~20.45 (m/s²)" 1386 "-20.48~20.45 (m/s²)" 1387 "-20.48~20.45 (m/s²)" 1388 "-20.48~20.45 (m/s²)" 1389 "-20.48~20.45 (m/s²)" 1390 "-20.48~20.45 (m/s²)" 1391 "-20.48~20.45 (m/s²)" 1392 "-20.48~20.45 (m/s²)" 1393 "-20.48~20.45 (m/s²)" 1394 "-20.48~20.45 (m/s²)" 1395 "-20.48~20.45 (m/s²)" 1396 "-20.48~20.45 (m/s²)" 1397 "-20.48~20.45 (m/s²)" 1398 "-20.48~20.45 (m/s²)" 1399 "-20.48~20.45 (m/s²)" 1400 "-20.48~20.45 (m/s²)" 1401 "-20.48~20.45 (m/s²)" 1402 "-20.48~20.45 (m/s²)" 1403 "-20.48~20.45 (m/s²)" 1404 "-20.48~20.45 (m/s²)" 1405 "-20.48~20.45 (m/s²)" 1406 "-20.48~20.45 (m/s²)" 1407 "-20.48~20.45 (m/s²)" 1408 "-20.48~20.45 (m/s²)" 1409 "-20.48~20.45 (m/s²)" 1410 "-20.48~20.45 (m/s²)" 1411 "-20.48~20.45 (m/s²)" 1412 "-20.48~20.45 (m/s²)" 1413 "-20.48~20.45 (m/s²)" 1414 "-20.48~20.45 (m/s²)" 1415 "-20.48~20.45 (m/s²)" 1416 "-20.48~20.45 (m/s²)" 1417 "-20.48~20.45 (m/s²)" 1418 "-20.48~20.45 (m/s²)" 1419 "-20.48~20.45 (m/s²)" 1420 "-20.48~20.45 (m/s²)" 1421 "-20.48~20.45 (m/s²)" 1422 "-20.48~20.45 (m/s²)" 1423 "-20.48~20.45 (m/s²)" 1424 "-20.48~20.45 (m/s²)" 1425 "-20.48~20.45 (m/s²)" 1426 "-20.48~20.45 (m/s²)" 1427 "-20.48~20.45 (m/s²)" 1428 "-20.48~20.45 (m/s²)" 1429 "-20.48~20.45 (m/s²)" 1430 "-20.48~20.45 (m/s²)" 1431 "-20.48~20.45 (m/s²)" 1432 "-20.48~20.45 (m/s²)" 1433 "-20.48~20.45 (m/s²)" 1434 "-20.48~20.45 (m/s²)" 1435 "-20.48~20.45 (m/s²)" 1436 "-20.48~20.45 (m/s²)" 1437 "-20.48~20.45 (m/s²)" 1438 "-20.48~20.45 (m/s²)" 1439 "-20.48~20.45 (m/s²)" 1440 "-20.48~20.45 (m/s²)" 1441 "-20.48~20.45 (m/s²)" 1442 "-20.48~20.45 (m/s²)" 1443 "-20.48~20.45 (m/s²)" 1444 "-20.48~20.45 (m/s²)" 1445 "-20.48~20.45 (m/s²)" 1446 "-20.48~20.45 (m/s²)" 1447 "-20.48~20.45 (m/s²)" 1448 "-20.48~20.45 (m/s²)" 1449 "-20.48~20.45 (m/s²)" 1450 "-20.48~20.45 (m/s²)" 1451 "-20.48~20.45 (m/s²)" 1452 "-20.48~20.45 (m/s²)" 1453 "-20.48~20.45 (m/s²)" 1454 "-20.48~20.45 (m/s²)" 1455 "-20.48~20.45 (m/s²)" 1456 "-20.48~20.45 (m/s²)" 1457 "-20.48~20.45 (m/s²)" 1458 "-20.48~20.45 (m/s²)" 1459 "-20.48~20.45 (m/s²)" 1460 "-20.48~20.45 (m/s²)" 1461 "-20.48~20.45 (m/s²)" 1462 "-20.48~20.45 (m/s²)" 1463 "-20.48~20.45 (m/s²)" 1464 "-20.48~20.45 (m/s²)" 1465 "-20.48~20.45 (m/s²)" 1466 "-20.48~20.45 (m/s²)" 1467 "-20.48~20.45 (m/s²)" 1468 "-20.48~20.45 (m/s²)" 1469 "-20.48~20.45 (m/s²)" 1470 "-20.48~20.45 (m/s²)" 1471 "-20.48~20.45 (m/s²)" 1472 "-20.48~20.45 (m/s²)" 1473 "-20.48~20.45 (m/s²)" 1474 "-20.48~20.45 (m/s²)" 1475 "-20.48~20.45 (m/s²)" 1476 "-20.48~20.45 (m/s²)" 1477 "-20.48~20.45 (m/s²)" 1478 "-20.48~20.45 (m/s²)" 1479 "-20.48~20.45 (m/s²)" 1480 "-20.48~20.45 (m/s²)" 1481 "-20.48~20.45 (m/s²)" 1482 "-20.48~20.45 (m/s²)" 1483 "-20.48~20.45 (m/s²)" 1484 "-20.48~20.45 (m/s²)" 1485 "-20.48~20.45 (m/s²)" 1486 "-20.48~20.45 (m/s²)" 1487 "-20.48~20.45 (m/s²)" 1488 "-20.48~20.45 (m/s²)" 1489 "-20.48~20.45 (m/s²)" 1490 "-20.48~20.45 (m/s²)" 1491 "-20.48~20.45 (m/s²)" 1492 "-20.48~20.45 (m/s²)" 1493 "-20.48~20.45 (m/s²)" 1494 "-20.48~20.45 (m/s²)" 1495 "-20.48~20.45 (m/s²)" 1496 "-20.48~20.45 (m/s²)" 1497 "-20.48~20.45 (m/s²)" 1498 "-20.48~20.45 (m/s²)" 1499 "-20.48~20.45 (m/s²)" 1500 "-20.48~20.45 (m/s²)" 1501 "-20.48~20.45 (m/s²)" 1502 "-20.48~20.45 (m/s²)" 1503 "-20.48~20.45 (m/s²)" 1504 "-20.48~20.45 (m/s²)" 1505 "-20.48~20.45 (m/s²)" 1506 "-20.48~20.45 (m/s²)" 1507 "-20.48~20.45 (m/s²)" 1508 "-20.48~20.45 (m/s²)" 1509 "-20.48~20.45 (m/s²)" 1510 "-20.48~20.45 (m/s²)" 1511 "-20.48~20.45 (m/s²)" 1512 "-20.48~20.45 (m/s²)" 1513 "-20.48~20.45 (m/s²)" 1514 "-20.48~20.45 (m/s²)" 1515 "-20.48~20.45 (m/s²)" 1516 "-20.48~20.45 (m/s²)" 1517 "-20.48~20.45 (m/s²)" 1518 "-20.48~20.45 (m/s²)" 1519 "-20.48~20.45 (m/s²)" 1520 "-20.48~20.45 (m/s²)" 1521 "-20.48~20.45 (m/s²)" 1522 "-20.48~20.45 (m/s²)" 1523 "-20.48~20.45 (m/s²)" 1524 "-20.48~20.45 (m/s²)" 1525 "-20.48~20.45 (m/s²)" 1526 "-20.48~20.45 (m/s²)" 1527 "-20.48~20.45 (m/s²)" 1528 "-20.48~20.45 (m/s²)" 1529 "-20.48~20.45 (m/s²)" 1530 "-20.48~20.45 (m/s²)" 1531 "-20.48~20.45 (m/s²)" 1532 "-20.48~20.45 (m/s²)" 1533 "-20.48~20.45 (m/s²)" 1534 "-20.48~20.45 (m/s²)" 1535 "-20.48~20.45 (m/s²)" 1536 "-20.48~20.45 (m/s²)" 1537 "-20.48~20.45 (m/s²)" 1538 "-20.48~20.45 (m/s²)" 1539 "-20.48~20.45 (m/s²)" 1540 "-20.48~20.45 (m/s²)" 1541 "-20.48~20.45 (m/s²)" 1542 "-20.48~20.45 (m/s²)" 1543 "-20.48~20.45 (m/s²)" 1544 "-20.48~20.45 (m/s²)" 1545 "-20.48~20.45 (m/s²)" 1546 "-20.48~20.45 (m/s²)" 1547 "-20.48~20.45 (m/s²)" 1548 "-20.48~20.45 (m/s²)" 1549 "-20.48~20.45 (m/s²)" 1550 "-20.48~20.45 (m/s²)" 1551 "-20.48~20.45 (m/s²)" 1552 "-20.48~20.45 (m/s²)" 1553 "-20.48~20.45 (m/s²)" 1554 "-20.48~20.45 (m/s²)" 1555 "-20.48~20.45 (m/s²)" 1556 "-20.48~20.45 (m/s²)" 1557 "-20.48~20.45 (m/s²)" 1558 "-20.48~20.45 (m/s²)" 1559 "-20.48~20.45 (m/s²)" 1560 "-20.48~20.45 (m/s²)" 1561 "-20.48~20.45 (m/s²)" 1562 "-20.48~20.45 (m/s²)" 1563 "-20.48~20.45 (m/s²)" 1564 "-20.48~20.45 (m/s²)" 1565 "-20.48~20.45 (m/s²)" 1566 "-20.48~20.45 (m/s²)" 1567 "-20.48~20.45 (m/s²)" 1568 "-20.48~20.45 (m/s²)" 1569 "-20.48~20.45 (m/s²)" 1570 "-20.48~20.45 (m/s²)" 1571 "-20.48~20.45 (m/s²)" 1572 "-20.48~20.45 (m/s²)" 1573 "-20.48~20.45 (m/s²)" 1574 "-20.48~20.45 (m/s²)" 1575 "-20.48~20.45 (m/s²)" 1576 "-20.48~20.45 (m/s²)" 1577 "-20.48~20.45 (m/s²)" 1578 "-20.48~20.45 (m/s²)" 1579 "-20.48~20.45 (m/s²)" 1580 "-20.48~20.45 (m/s²)" 1581 "-20.48~20.45 (m/s²)" 1582 "-20.48~20.45 (m/s²)" 1583 "-20.48~20.45 (m/s²)" 1584 "-20.48~20.45 (m/s²)" 1585 "-20.48~20.45 (m/s²)" 1586 "-20.48~20.45 (m/s²)" 1587 "-20.48~20.45 (m/s²)" 1588 "-20.48~20.45 (m/s²)" 1589 "-20.48~20.45 (m/s²)" 1590 "-20.48~20.45 (m/s²)" 1591 "-20.48~20.45 (m/s²)" 1592 "-20.48~20.45 (m/s²)" 1593 "-20.48~20.45 (m/s²)" 1594 "-20.48~20.45 (m/s²)" 1595 "-20.48~20.45 (m/s²)" 1596 "-20.48~20.45 (m/s²)" 1597 "-20.48~20.45 (m/s²)" 1598 "-20.48~20.45 (m/s²)" 1599 "-20.48~20.45 (m/s²)" 1600 "-20.48~20.45 (m/s²)" 1601 "-20.48~20.45 (m/s²)" 1602 "-20.48~20.45 (m/s²)" 1603 "-20.48~20.45 (m/s²)" 1604 "-20.48~20.45 (m/s²)" 1605 "-20.48~20.45 (m/s²)" 1606 "-20.48~20.45 (m/s²)" 1607 "-20.48~20.45 (m/s²)" 1608 "-20.48~20.45 (m/s²)" 1609 "-20.48~20.45 (m/s²)" 1610 "-20.48~20.45 (m/s²)" 1611 "-20.48~20.45 (m/s²)" 1612 "-20.48~20.45 (m/s²)" 1613 "-20.48~20.45 (m/s²)" 1614 "-20.48~20.45 (m/s²)" 1615 "-20.48~20.45 (m/s²)" 1616 "-20.48~20.45 (m/s²)" 1617 "-20.48~20.45 (m/s²)" 1618 "-20.48~20.45 (m/s²)" 1619 "-20.48~20.45 (m/s²)" 1620 "-20.48~20.45 (m/s²)" 1621 "-20.48~20.45 (m/s²)" 1622 "-20.48~20.45 (m/s²)" 1623 "-20.48~20.45 (m/s²)" 1624 "-20.48~20.45 (m/s²)" 1625 "-20.48~20.45 (m/s²)" 1626 "-20.48~20.45 (m/s²)" 1627 "-20.48~20.45 (m/s²)" 1628 "-20.48~20.45 (m/s²)" 1629 "-20.48~20.45 (m/s²)" 1630 "-20.48~20.45 (m/s²)" 1631 "-20.48~20.45 (m/s²)" 1632 "-20.48~20.45 (m/s²)" 1633 "-20.48~20.45 (m/s²)" 1634 "-20.48~20.45 (m/s²)" 1635 "-20.48~20.45 (m/s²)" 1636 "-20.48~20.45 (m/s²)" 1637 "-20.48~20.45 (m/s²)" 1638 "-20.48~20.45 (m/s²)" 1639 "-20.48~20.45 (m/s²)" 1640 "-20.48~20.45 (m/s²)" 1641 "-20.48~20.45 (m/s²)" 1642 "-20.48~20.45 (m/s²)" 1643 "-20.48~20.45 (m/s²)" 1644 "-20.48~20.45 (m/s²)" 1645 "-20.48~20.45 (m/s²)" 1646 "-20.48~20.45 (m/s²)" 1647 "-20.48~20.45 (m/s²)" 1648 "-20.48~20.45 (m/s²)" 1649 "-20.48~20.45 (m/s²)" 1650 "-20.48~20.45 (m/s²)" 1651 "-20.48~20.45 (m/s²)" 1652 "-20.48~20.45 (m/s²)" 1653 "-20.48~20.45 (m/s²)" 1654 "-20.48~20.45 (m/s²)" 1655 "-20.48~20.45 (m/s²)" 1656 "-20.48~20.45 (m/s²)" 1657 "-20.48~20.45 (m/s²)" 1658 "-20.48~20.45 (m/s²)" 1659 "-20.48~20.45 (m/s²)" 1660 "-20.48~20.45 (m/s²)" 1661 "-20.48~20.45 (m/s²)" 1662 "-20.48~20.45 (m/s²)" 1663 "-20.48~20.45 (m/s²)" 1664 "-20.48~20.45 (m/s²)" 1665 "-20.48~20.45 (m/s²)" 1666 "-20.48~20.45 (m/s²)" 1667 "-20.48~20.45 (m/s²)" 1668 "-20.48~20.45 (m/s²)" 1669 "-20.48~20.45 (m/s²)" 1670 "-20.48~20.45 (m/s²)" 1671 "-20.48~20.45 (m/s²)" 1672 "-20.48~20.45 (m/s²)" 1673 "-20.48~20.45 (m/s²)" 1674 "-20.48~20.45 (m/s²)" 1675 "-20.48~20.45 (m/s²)" 1676 "-20.48~20.45 (m/s²)" 1677 "-20.48~20.45 (m/s²)" 1678 "-20.48~20.45 (m/s²)" 1679 "-20.48~20.45 (m/s²)" 1680 "-20.48~20.45 (m/s²)" 1681 "-20.48~20.45 (m/s²)" 1682 "-20.48~20.45 (m/s²)" 1683 "-20.48~20.45 (m/s²)" 1684 "-20.48~20.45 (m/s²)" 1685 "-20.48~20.45 (m/s²)" 1686 "-20.48~20.45 (m/s²)" 1687 "-20.48~20.45 (m/s²)" 1688 "-20.48~20.45 (m/s²)" 1689 "-20.48~20.45 (m/s²)" 1690 "-20.48~20.45 (m/s²)" 1691 "-20.48~20.45 (m/s²)" 1692 "-20.48~20.45 (m/s²)" 1693 "-20.48~20.45 (m/s²)" 1694 "-20.48~20.45 (m/s²)" 1695 "-20.48~20.45 (m/s²)" 1696 "-20.48~20.45 (m/s²)" 1697 "-20.48~20.45 (m/s²)" 1698 "-20.48~20.45 (m/s²)" 1699 "-20.48~20.45 (m/s²)" 1700 "-20.48~20.45 (m/s²)" 1701 "-20.48~20.45 (m/s²)" 1702 "-20.48~20.45 (m/s²)" 1703 "-20.48~20.45 (m/s²)" 1704 "-20.48~20.45 (m/s²)" 1705 "-20.48~20.45 (m/s²)" 1706 "-20.48~20.45 (m/s²)" 1707 "-20.48~20.45 (m/s²)" 1708 "-20.48~20.45 (m/s²)" 1709 "-20.48~20.45 (m/s²)" 1710 "-20.48~20.45 (m/s²)" 1711 "-20.48~20.45 (m/s²)" 1712 "-20.48~20.45 (m/s²)" 1713 "-20.48~20.45 (m/s²)" 1714 "-20.48~20.45 (m/s²)" 1715 "-20.48~20.45 (m/s²)" 1716 "-20.48~20.45 (m/s²)" 1717 "-20.48~20.45 (m/s²)" 1718 "-20.48~20.45 (m/s²)" 1719 "-20.48~20.45 (m/s²)" 1720 "-20.48~20.45 (m/s²)" 1721 "-20.48~20.45 (m/s²)" 1722 "-20.48~20.45 (m/s²)" 1723 "-20.48~20.45 (m/s²)" 1724 "-20.48~20.45 (m/s²)" 1725 "-20.48~20.45 (m/s²)" 1726 "-20.48~20.45 (m/s²)" 1727 "-20.48~20.45 (m/s²)" 1728 "-20.48~20.45 (m/s²)" 1729 "-20.48~20.45 (m/s²)" 1730 "-20.48~20.45 (m/s²)" 1731 "-20.48~20.45 (m/s²)" 1732 "-20.48~20.45 (m/s²)" 1733 "-20.48~20.45 (m/s²)" 1734 "-20.48~20.45 (m/s²)" 1735 "-20.48~20.45 (m/s²)" 1736 "-20.48~20.45 (m/s²)" 1737 "-20.48~20.45 (m/s²)" 1738 "-20.48~20.45 (m/s²)" 1739 "-20.48~20.45 (m/s²)" 1740 "-20.48~20.45 (m/s²)" 1741 "-20.48~20.45 (m/s²)" 1742 "-20.48~20.45 (m/s²)" 1743 "-20.48~20.45 (m/s²)" 1744 "-20.48~20.45 (m/s²)" 1745 "-20.48~20.45 (m/s²)" 1746 "-20.48~20.45 (m/s²)" 1747 "-20.48~20.45 (m/s²)" 1748 "-20.48~20.45 (m/s²)" 1749 "-20.48~20.45 (m/s²)" 1750 "-20.48~20.45 (m/s²)" 1751 "-20.48~20.45 (m/s²)" 1752 "-20.48~20.45 (m/s²)" 1753 "-20.48~20.45 (m/s²)" 1754 "-20.48~20.45 (m/s²)" 1755 "-20.48~20.45 (m/s²)" 1756 "-20.48~20.45 (m/s²)" 1757 "-20.48~20.45 (m/s²)" 1758 "-20.48~20.45 (m/s²)" 1759 "-20.48~20.45 (m/s²)" 1760 "-20.48~20.45 (m/s²)" 1761 "-20.48~20.45 (m/s²)" 1762 "-20.48~20.45 (m/s²)" 1763 "-20.48~20.45 (m/s²)" 1764 "-20.48~20.45 (m/s²)" 1765 "-20.48~20.45 (m/s²)" 1766 "-20.48~20.45 (m/s²)" 1767 "-20.48~20.45 (m/s²)" 1768 "-20.48~20.45 (m/s²)" 1769 "-20.48~20.45 (m/s²)" 1770 "-20.48~20.45 (m/s²)" 1771 "-20.48~20.45 (m/s²)" 1772 "-20.48~20.45 (m/s²)" 1773 "-20.48~20.45 (m/s²)" 1774 "-20.48~20.45 (m/s²)" 1775 "-20.48~20.45 (m/s²)" 1776 "-20.48~20.45 (m/s²)" 1777 "-20.48~20.45 (m/s²)" 1778 "-20.48~20.45 (m/s²)" 1779 "-20.48~20.45 (m/s²)" 1780 "-20.48~20.45 (m/s²)" 1781 "-20.48~20.45 (m/s²)" 1782 "-20.48~20.45 (m/s²)" 1783 "-20.48~20.45 (m/s²)" 1784 "-20.48~20.45 (m/s²)" 1785 "-20.48~20.45 (m/s²)" 1786 "-20.48~20.45 (m/s²)" 1787 "-20.48~20.45 (m/s²)" 1788 "-20.48~20.45 (m/s²)" 1789 "-20.48~20.45 (m/s²)" 1790 "-20.48~20.45 (m/s²)" 1791 "-20.48~20.45 (m/s²)" 1792 "-20.48~20.45 (m/s²)" 1793 "-20.48~20.45 (m/s²)" 1794 "-20.48~20.45 (m/s²)" 1795 "-20.48~20.45 (m/s²)" 1796 "-20.48~20.45 (m/s²)" 1797 "-20.48~20.45 (m/s²)" 1798 "-20.48~20.45 (m/s²)" 1799 "-20.48~20.45 (m/s²)" 1800 "-20.48~20.45 (m/s²)" 1801 "-20.48~20.45 (m/s²)" 1802 "-20.48~20.45 (m/s²)" 1803 "-20.48~20.45 (m/s²)" 1804 "-20.48~20.45 (m/s²)" 1805 "-20.48~20.45 (m/s²)" 1806 "-20.48~20.45 (m/s²)" 1807 "-20.48~20.45 (m/s²)" 1808 "-20.48~20.45 (m/s²)" 1809 "-20.48~20.45 (m/s²)" 1810 "-20.48~20.45 (m/s²)" 1811 "-20.48~20.45 (m/s²)" 1812 "-20.48~20.45 (m/s²)" 1813 "-20.48~20.45 (m/s²)" 1814 "-20.48~20.45 (m/s²)" 1815 "-20.48~20.45 (m/s²)" 1816 "-20.48~20.45 (m/s²)" 1817 "-20.48~20.45 (m/s²)" 1818 "-20.48~20.45 (m/s²)" 1819 "-20.48~20.45 (m/s²)" 1820 "-20.48~20.45 (m/s²)" 1821 "-20.48~20.45 (m/s²)" 1822 "-20.48~20.45 (m/s²)" 1823 "-20.48~20.45 (m/s²)" 1824 "-20.48~20.45 (m/s²)" 1825 "-20.48~20.45 (m/s²)" 1826 "-20.48~20.45 (m/s²)" 1827 "-20.48~20.45 (m/s²)" 1828 "-20.48~20.45 (m/s²)" 1829 "-20.48~20.45 (m/s²)" 1830 "-20.48~20.45 (m/s²)" 1831 "-20.48~20.45 (m/s²)" 1832 "-20.48~20.45 (m/s²)" 1833 "-20.48~20.45 (m/s²)" 1834 "-20.48~20.45 (m/s²)" 1835 "-20.48~20.45 (m/s²)" 1836 "-20.48~20.45 (m/s²)" 1837 "-20.48~20.45 (m/s²)" 1838 "-20.48~20.45 (m/s²)" 1839 "-20.48~20.45 (m/s²)" 1840 "-20.48~20.45 (m/s²)" 1841 "-20.48~20.45 (m/s²)" 1842 "-20.48~20.45 (m/s²)" 1843 "-20.48~20.45 (m/s²)" 1844 "-20.48~20.45 (m/s²)" 1845 "-20.48~20.45 (m/s²)" 1846 "-20.48~20.45 (m/s²)" 1847 "-20.48~20.45 (m/s²)" 1848 "-20.48~20.45 (m/s²)" 1849 "-20.48~20.45 (m/s²)" 1850 "-20.48~20.45 (m/s²)" 1851 "-20.48~20.45 (m/s²)" 1852 "-20.48~20.45 (m/s²)" 1853 "-20.48~20.45 (m/s²)" 1854 "-20.48~20.45 (m/s²)" 1855 "-20.48~20.45 (m/s²)" 1856 "-20.48~20.45 (m/s²)" 1857 "-20.48~20.45 (m/s²)" 1858 "-20.48~20.45 (m/s²)" 1859 "-20.48~20.45 (m/s²)" 1860 "-20.48~20.45 (m/s²)" 1861 "-20.48~20.45 (m/s²)" 1862 "-20.48~20.45 (m/s²)" 1863 "-20.48~20.45 (m/s²)" 1864 "-20.48~20.45 (m/s²)" 1865 "-20.48~20.45 (m/s²)" 1866 "-20.48~20.45 (m/s²)" 1867 "-20.48~20.45 (m/s²)" 1868 "-20.48~20.45 (m/s²)" 1869 "-20.48~20.45 (m/s²)" 1870 "-20.48~20.45 (m/s²)" 1871 "-20.48~20.45 (m/s²)" 1872 "-20.48~20.45 (m/s²)" 1873 "-20.48~20.45 (m/s²)" 1874 "-20.48~20.45 (m/s²)" 1875 "-20.48~20.45 (m/s²)" 1876 "-20.48~20.45 (m/s²)" 1877 "-20.48~20.45 (m/s²)" 1878 "-20.48~20.45 (m/s²)" 1879 "-20.48~20.45 (m/s²)" 1880 "-20.48~20.45 (m/s²)" 1881 "-20.48~20.45 (m/s²)" 1882 "-20.48~20.45 (m/s²)" 1883 "-20.48~20.45 (m/s²)" 1884 "-20.48~20.45 (m/s²)" 1885 "-20.48~20.45 (m/s²)" 1886 "-20.48~20.45 (m/s²)" 1887 "-20.48~20.45 (m/s²)" 1888 "-20.48~20.45 (m/s²)" 1889 "-20.48~20.45 (m/s²)" 1890 "-20.48~20.45 (m/s²)" 1891 "-20.48~20.45 (m/s²)" 1892 "-20.48~20.45 (m/s²)" 1893 "-20.48~20.45 (m/s²)" 1894 "-20.48~20.45 (m/s²)" 1895 "-20.48~20.45 (m/s²)" 1896 "-20.48~20.45 (m/s²)" 1897 "-20.48~20.45 (m/s²)" 1898 "-20.48~20.45 (m/s²)" 1899 "-20.48~20.45 (m/s²)" 1900 "-20.48~20.45 (m/s²)" 1901 "-20.48~20.45 (m/s²)" 1902 "-20.48~20.45 (m/s²)" 1903 "-20.48~20.45 (m/s²)" 1904 "-20.48~20.45 (m/s²)" 1905 "-20.48~20.45 (m/s²)" 1906 "-20.48~20.45 (m/s²)" 1907 "-20.48~20.45 (m/s²)" 1908 "-20.48~20.45 (m/s²)" 1909 "-20.48~20.45 (m/s²)" 1910 "-20.48~20.45 (m/s²)" 1911 "-20.48~20.45 (m/s²)" 1912 "-20.48~20.45 (m/s²)" 1913 "-20.48~20.45 (m/s²)" 1914 "-20.48~20.45 (m/s²)" 1915 "-20.48~20.45 (m/s²)" 1916 "-20.48~20.45 (m/s²)" 1917 "-20.48~20.45 (m/s²)" 1918 "-20.48~20.45 (m/s²)" 1919 "-20.48~20.45 (m/s²)" 1920 "-20.48~20.45 (m/s²)" 1921 "-20.48~20.45 (m/s²)" 1922 "-20.48~20.45 (m/s²)" 1923 "-20.48~20.45 (m/s²)" 1924 "-20.48~20.45 (m/s²)" 1925 "-20.48~20.45 (m/s²)" 1926 "-20.48~20.45 (m/s²)" 1927 "-20.48~20.45 (m/s²)" 1928 "-20.48~20.45 (m/s²)" 1929 "-20.48~20.45 (m/s²)" 1930 "-20.48~20.45 (m/s²)" 1931 "-20.48~20.45 (m/s²)" 1932 "-20.48~20.45 (m/s²)" 1933 "-20.48~20.45 (m/s²)" 1934 "-20.48~20.45 (m/s²)" 1935 "-20.48~20.45 (m/s²)" 1936 "-20.48~20.45 (m/s²)" 1937 "-20.48~20.45 (m/s²)" 1938 "-20.48~20.45 (m/s²)" 1939 "-20.48~20.45 (m/s²)" 1940 "-20.48~20.45 (m/s²)" 1941 "-20.48~20.45 (m/s²)" 1942 "-20.48~20.45 (m/s²)" 1943 "-20.48~20.45 (m/s²)" 1944 "-20.48~20.45 (m/s²)" 1945 "-20.48~20.45 (m/s²)" 1946 "-20.48~20.45 (m/s²)" 1947 "-20.48~20.45 (m/s²)" 1948 "-20.48~20.45 (m/s²)" 1949 "-20.48~20.45 (m/s²)" 1950 "-20.48~20.45 (m/s²)" 1951 "-20.48~20.45 (m/s²)" 1952 "-20.48~20.45 (m/s²)" 1953 "-20.48~20.45 (m/s²)" 1954 "-20.48~20.45 (m/s²)" 1955 "-20.48~20.45 (m/s²)" 1956 "-20.48~20.45 (m/s²)" 1957 "-20.48~20.45 (m/s²)" 1958 "-20.48~20.45 (m/s²)" 1959 "-20.48~20.45 (m/s²)" 1960 "-20.48~20.45 (m/s²)" 1961 "-20.48~20.45 (m/s²)" 1962 "-20.48~20.45 (m/s²)" 1963 "-20.48~20.45 (m/s²)" 1964 "-20.48~20.45 (m/s²)" 1965 "-20.48~20.45 (m/s²)" 1966 "-20.48~20.45 (m/s²)" 1967 "-20.48~20.45 (m/s²)" 1968 "-20.48~20.45 (m/s²)" 1969 "-20.48~20.45 (m/s²)" 1970 "-20.48~20.45 (m/s²)" 1971 "-20.48~20.45 (m/s²)" 1972 "-20.48~20.45 (m/s²)" 1973 "-20.48~20.45 (m/s²)" 1974 "-20.48~20.45 (m/s²)" 1975 "-20.48~20.45 (m/s²)" 1976 "-20.48~20.45 (m/s²)" 1977 "-20.48~20.45 (m/s²)" 1978 "-20.48~20.45 (m/s²)" 1979 "-20.48~20.45 (m/s²)" 1980 "-20.48~20.45 (m/s²)" 1981 "-20.48~20.45 (m/s²)" 1982 "-20.48~20.45 (m/s²)" 1983 "-20.48~20.45 (m/s²)" 1984 "-20.48~20.45 (m/s²)" 1985 "-20.48~20.45 (m/s²)" 1986 "-20.48~20.45 (m/s²)" 1987 "-20.48~20.45 (m/s²)" 1988 "-20.48~20.45 (m/s²)" 1989 "-20.48~20.45 (m/s²)" 1990 "-20.48~20.45 (m/s²)" 1991 "-20.48~20.45 (m/s²)" 1992 "-20.48~20.45 (m/s²)" 1993 "-20.48~20.45 (m/s²)" 1994 "-20.48~20.45 (m/s²)" 1995 "-20.48~20.45 (m/s²)" 1996 "-20.48~20.45 (m/s²)" 1997 "-20.48~20.45 (m/s²)" 1998 "-20.48~20.45 (m/s²)" 1999 "-20.48~20.45 (m/s²)" 2000 "-20.48~20.45 (m/s²)" 2001 "-20.48~20.45 (m/s²)" 2002 "-20.48~20.45 (m/s²)" 2003 "-20.48~20.45 (m/s²)" 2004 "-20.48~20.45 (m/s²)" 2005 "-20.48~20.45 (m/s²)" 2006 "-20.48~20.45 (m/s²)" 2007 "-20.48~20.45 (m/s²)" 2008 "-20.48~20.45 (m/s²)" 2009 "-20.48~20.45 (m/s²)" 2010 "-20.48~20.45 (m/s²)" 2011 "-20.48~20.45 (m/s²)" 2012 "-20.48~20.45 (m/s²)" 2013 "-20.48~20.45 (m/s²)" 2014 "-20.48~20.45 (m/s²)" 2015 "-20.48~20.45 (m/s²)" 2016 "-20.48~20.45 (m/s²)" 2017 "-20.48~20.45 (m/s²)" 2018 "-20.48~20.45 (m/s²)" 2019 "-20.48~20.45 (m/s²)" 2020 "-20.48~20.45 (m/s²)" 2021 "-20.48~20.45 (m/s²)" 2022 "-20.48~20.45 (m/s²)" 2023 "-20.48~20.45 (m/s²)" 2024 "-20.48~20.45 (m/s²)" 2025 "-20.48~20.45 (m/s²)" 2026 "-20.48~20.45 (m/s²)" 2027 "-20.48~20.45 (m/s²)" 2028 "-20.48~20.45 (m/s²)" 2029 "-20.48~20.45 (m/s²)" 2030 "-20.48~20.45 (m/s²)" 2031 "-20.48~20.45 (m/s²)" 2032 "-20.48~20.45 (m/s²)" 2033 "-20.48~20.45 (m/s²)" 2034 "-20.48~20.45 (m/s²)" 2035 "-20.48~20.45 (m/s²)" 2036 "-20.48~20.45 (m/s²)" 2037 "-20.48~20.45 (m/s²)" 2038 "-20.48~20.45 (m/s²)" 2039 "-20.48~20.45 (m/s²)" 2040 "-20.48~20.45 (m/s²)" 2041 "-20.48~20.45 (m/s²)" 2042 "-20.48~20.45 (m/s²)" 2043 "-20.48~20.45 (m/s²)" 2044 "-20.48~20.45 (m/s²)" 2045 "-20.48~20.45 (m/s²)" 2046 "-20.48~20.45 (m/s²)" 2047 "-20.48~20.45 (m/s²)" 2048 "-20.48~20.45 (m/s²)" 2049 "-20.48~20.45 (m/s²)" 2050 "-20.48~20.45 (m/s²)" 2051 "-20.48~20.45 (m/s²)" 2052 "-20.48~20.45 (m/s²)" 2053 "-20.48~20.45 (m/s²)" 2054 "-20.48~20.45 (m/s²)" 2055 "-20.48~20.45 (m/s²)" 2056 "-20.48~20.45 (m/s²)" 2057 "-20.48~20.45 (m/s²)" 2058 "-20.48~20.45 (m/s²)" 2059 "-20.48~20.45 (m/s²)" 2060 "-20.48~20.45 (m/s²)" 2061 "-20.48~20.45 (m/s²)" 2062 "-20.48~20.45 (m/s²)" 2063 "-20.48~20.45 (m/s²)" 2064 "-20.48~20.45 (m/s²)" 2065 "-20.48~20.45 (m/s²)" 2066 "-20.48~20.45 (m/s²)" 2067 "-20.48~20.45 (m/s²)" 2068 "-20.48~20.45 (m/s²)" 2069 "-20.48~20.45 (m/s²)" 2070 "-20.48~20.45 (m/s²)" 2071 "-20.48~20.45 (m/s²)" 2072 "-20.48~20.45 (m/s²)" 2073 "-20.48~20.45 (m/s²)" 2074 "-20.48~20.45 (m/s²)" 2075 "-20.48~20.45 (m/s²)" 2076 "-20.48~20.45 (m/s²)" 2077 "-20.48~20.45 (m/s²)" 2078 "-20.48~20.45 (m/s²)" 2079 "-20.48~20.45 (m/s²)" 2080 "-20.48~20.45 (m/s²)" 2081 "-20.48~20.45 (m/s²)" 2082 "-20.48~20.45 (m/s²)" 2083 "-20.48~20.45 (m/s²)" 2084 "-20.48~20.45 (m/s²)" 2085 "-20.48~20.45 (m/s²)" 2086 "-20.48~20.45 (m/s²)" 2087 "-20.48~20.45 (m/s²)" 2088 "-20.48~20.45 (m/s²)" 2089 "-20.48~20.45 (m/s²)" 2090 "-20.48~20.45 (m/s²)" 2091 "-20.48~20.45 (m/s²)" 2092 "-20.48~20.45 (m/s²)" 2093 "-20.48~20.45 (m/s²)" 2094 "-20.48~20.45 (m/s²)" 2095 "-20.48~20.45 (m/s²)" 2096 "-20.48~20.45 (m/s²)" 2097 "-20.48~20.45 (m/s²)" 2098 "-20.48~20.45 (m/s²)" 2099 "-20.48~20.45 (m/s²)" 2100 "-20.48~20.45 (m/s²)" 2101 "-20.48~20.45 (m/s²)" 2102 "-20.48~20.45 (m/s²)" 2103 "-20.48~20.45 (m/s²)" 2104 "-20.48~20.45 (m/s²)" 2105 "-20.48~20.45 (m/s²)" 2106 "-20.48~20.45 (m/s²)" 2107 "-20.48~20.45 (m/s²)" 2108 "-20.48~20.45 (m/s²)" 2109 "-20.48~20.45 (m/s²)" 2110 "-20.48~20.45 (m/s²)" 2111 "-20.48~20.45 (m/s²)" 2112 "-20.48~20.45 (m/s²)" 2113 "-20.48~20.45 (m/s²)" 2114 "-20.48~20.45 (m/s²)" 2115 "-20.48~20.45 (m/s²)" 2116 "-20.48~20.45 (m/s²)" 2117 "-20.48~20.45 (m/s²)" 2118 "-20.48~20.45 (m/s²)" 2119 "-20.48~20.45 (m/s²)" 2120 "-20.48~20.45 (m/s²)" 2121 "-20.48~20.45 (m/s²)" 2122 "-20.48~20.45 (m/s²)" 2123 "-20.48~20.45 (m/s²)" 2124 "-20.48~20.45 (m/s²)" 2125 "-20.48~20.45 (m/s²)" 2126 "-20.48~20.45 (m/s²)" 2127 "-20.48~20.45 (m/s²)" 2128 "-20.48~20.45 (m/s²)" 2129 "-20.48~20.45 (m/s²)" 2130 "-20.48~20.45 (m/s²)" 2131 "-20.48~20.45 (m/s²)" 2132 "-20.48~20.45 (m/s²)" 2133 "-20.48~20.45 (m/s²)" 2134 "-20.48~20.45 (m/s²)" 2135 "-20.48~20.45 (m/s²)" 2136 "-20.48~20.45 (m/s²)" 2137 "-20.48~20.45 (m/s²)" 2138 "-20.48~20.45 (m/s²)" 2139 "-20.48~20.45 (m/s²)" 2140 "-20.48~20.45 (m/s²)" 2141 "-20.48~20.45 (m/s²)" 2142 "-20.48~20.45 (m/s²)" 2143 "-20.48~20.45 (m/s²)" 2144 "-20.48~20.45 (m/s²)" 2145 "-20.48~20.45 (m/s²)" 2146 "-20.48~20.45 (m/s²)" 2147 "-20.48~20.45 (m/s²)" 2148 "-20.48~20.45 (m/s²)" 2149 "-20.48~20.45 (m/s²)" 2150 "-20.48~20.45 (m/s²)" 2151 "-20.48~20.45 (m/s²)" 2152 "-20.48~20.45 (m/s²)" 2153 "-20.48~20.45 (m/s²)" 2154 "-20.48~20.45 (m/s²)" 2155 "-20.48~20.45 (m/s²)" 2156 "-20.48~20.45 (m/s²)" 2157 "-20.48~20.45 (m/s²)" 2158 "-20.48~20.45 (m/s²)" 2159 "-20.48~20.45 (m/s²)" 2160 "-20.48~20.45 (m/s²)" 2161 "-20.48~20.45 (m/s²)" 2162 "-20.48~20.45 (m/s²)" 2163 "-20.48~20.45 (m/s²)" 2164 "-20.48~20.45 (m/s²)" 2165 "-20.48~20.45 (m/s²)" 2166 "-20.48~20.45 (m/s²)" 2167 "-20.48~20.45 (m/s²)" 2168 "-20.48~20.45 (m/s²)" 2169 "-20.48~20.45 (m/s²)" 2170 "-20.48~20.45 (m/s²)" 2171 "-20.48~20.45 (m/s²)" 2172 "-20.48~20.45 (m/s²)" 2173 "-20.48~20.45 (m/s²)" 2174 "-20.48~20.45 (m/s²)" 2175 "-20.48~20.45 (m/s²)" 2176 "-20.48~20.45 (m/s²)" 2177 "-20.48~20.45 (m/s²)" 2178 "-20.48~20.45 (m/s²)" 2179 "-20.48~20.45 (m/s²)" 2180 "-20.48~20.45 (m/s²)" 2181 "-20.48~20.45 (m/s²)" 2182 "-20.48~20.45 (m/s²)" 2183 "-20.48~20.45 (m/s²)" 2184 "-20.48~20.45 (m/s²)" 2185 "-20.48~20.45 (m/s²)" 2186 "-20.48~20.45 (m/s²)" 2187 "-20.48~20.45 (m/s²)" 2188 "-20.48~20.45 (m/s²)" 2189 "-20.48~20.45 (m/s²)" 2190 "-20.48~20.45 (m/s²)" 2191 "-20.48~20.45 (m/s²)" 2192 "-20.48~20.45 (m/s²)" 2193 "-20.48~20.45 (m/s²)" 2194 "-20.48~20.45 (m/s²)" 2195 "-20.48~20.45 (m/s²)" 2196 "-20.48~20.45 (m/s²)" 2197 "-20.48~20.45 (m/s²)" 2198 "-20.48~20.45 (m/s²)" 2199 "-20.48~20.45 (m/s²)" 2200 "-20.48~20.45 (m/s²)" 2201 "-20.48~20.45 (m/s²)" 2202 "-20.48~20.45 (m/s²)" 2203 "-20.48~20.45 (m/s²)" 2204 "-20.48~20.45 (m/s²)" 2205 "-20.48~20.45 (m/s²)" 2206 "-20.48~20.45 (m/s²)" 2207 "-20.48~20.45 (m/s²)" 2208 "-20.48~20.45 (m/s²)" 2209 "-20.48~20.45 (m/s²)" 2210 "-20.48~20.45 (m/s²)" 2211 "-20.48~20.45 (m/s²)" 2212 "-20.48~20.45 (m/s²)" 2213 "-20.48~20.45 (m/s²)" 2214 "-20.48~20.45 (m/s²)" 2215 "-20.48~20.45 (m/s²)" 2216 "-20.48~20.45 (m/s²)" 2217 "-20.48~20.45 (m/s²)" 2218 "-20.48~20.45 (m/s²)" 2219 "-20.48~20.45 (m/s²)" 2220 "-20.48~20.45 (m/s²)" 2221 "-20.48~20.45 (m/s²)" 2222 "-20.48~20.45 (m/s²)" 2223 "-20.48~20.45 (m/s²)" 2224 "-20.48~20.45 (m/s²)" 2225 "-20.48~20.45 (m/s²)" 2226 "-20.48~20.45 (m/s²)" 2227 "-20.48~20.45 (m/s²)" 2228 "-20.48~20.45 (m/s²)" 2229 "-20.48~20.45 (m/s²)" 2230 "-20.48~20.45 (m/s²)" 2231 "-20.48~20.45 (m/s²)" 2232 "-20.48~20.45 (m/s²)" 2233 "-20.48~20.45 (m/s²)" 2234 "-20.48~20.45 (m/s²)" 2235 "-20.48~20.45 (m/s²)" 2236 "-20.48~20.45 (m/s²)" 2237 "-20.48~20.45 (m/s²)" 2238 "-20.48~20.45 (m/s²)" 2239 "-20.48~20.45 (m/s²)" 2240 "-20.48~20.45 (m/s²)" 2241 "-20.48~20.45 (m/s²)" 2242 "-20.48~20.45 (m/s²)" 2243 "-20.48~20.45 (m/s²)" 2244 "-20.48~20.45 (m/s²)" 2245 "-20.48~20.45 (m/s²)" 2246 "-20.48~20.45 (m/s²)" 2247 "-20.48~20.45 (m/s²)" 2248 "-20.48~20.45 (m/s²)" 2249 "-20.48~20.45 (m/s²)" 2250 "-20.48~20.45 (m/s²)" 2251 "-20.48~20.45 (m/s²)" 2252 "-20.48~20.45 (m/s²)" 2253 "-20.48~20.45 (m/s²)" 2254 "-20.48~20.45 (m/s²)" 2255 "-20.48~20.45 (m/s²)" 2256 "-20.48~20.45 (m/s²)" 2257 "-20.48~20.45 (m/s²)" 2258 "-20.48~20.45 (m/s²)" 2259 "-20.48~20.45 (m/s²)" 2260 "-20.48~20.45 (m/s²)" 2261 "-20.48~20.45 (m/s²)" 2262 "-20.48~20.45 (m/s²)" 2263 "-20.48~20.45 (m/s²)" 2264 "-20.48~20.45 (m/s²)" 2265 "-20.48~20.45 (m/s²)" 2266 "-20.48~20.45 (m/s²)" 2267 "-20.48~20.45 (m/s²)" 2268 "-20.48~20.45 (m/s²)" 2269 "-20.48~20.45 (m/s²)" 2270 "-20.48~20.45 (m/s²)" 2271 "-20.48~20.45 (m/s²)" 2272 "-20.48~20.45 (m/s²)" 2273 "-20.48~20.45 (m/s²)" 2274 "-20.48~20.45 (m/s²)" 2275 "-20.48~20.45 (m/s²)" 2276 "-20.48~20.45 (m/s²)" 2277 "-20.48~20.45 (m/s²)" 2278 "-20.48~20.45 (m/s²)" 2279 "-20.48~20.45 (m/s²)" 2280 "-20.48~20.45 (m/s²)" 2281 "-20.48~20.45 (m/s²)" 2282 "-20.48~20.45 (m/s²)" 2283 "-20.48~20.45 (m/s²)" 2284 "-20.48~20.45 (m/s²)" 2285 "-20.48~20.45 (m/s²)" 2286 "-20.48~20.45 (m/s²)" 2287 "-20.48~20.45 (m/s²)" 2288 "-20.48~20.45 (m/s²)" 2289 "-20.48~20.45 (m/s²)" 2290 "-20.48~20.45 (m/s²)" 2291 "-20.48~20.45 (m/s²)" 2292 "-20.48~20.45 (m/s²)" 2293 "-20.48~20.45 (m/s²)" 2294 "-20.48~20.45 (m/s²)" 2295 "-20.48~20.45 (m/s²)" 2296 "-20.48~20.45 (m/s²)" 2297 "-20.48~20.45 (m/s²)" 2298 "-20.48~20.45 (m/s²)" 2299 "-20.48~20.45 (m/s²)" 2300 "-20.48~20.45 (m/s²)" 2301 "-20.48~20.45 (m/s²)" 2302 "-20.48~20.45 (m/s²)" 2303 "-20.48~20.45 (m/s²)" 2304 "-20.48~20.45 (m/s²)" 2305 "-20.48~20.45 (m/s²)" 2306 "-20.48~20.45 (m/s²)" 2307 "-20.48~20.45 (m/s²)" 2308 "-20.48~20.45 (m/s²)" 2309 "-20.48~20.45 (m/s²)" 2310 "-20.48~20.45 (m/s²)" 2311 "-20.48~20.45 (m/s²)" 2312 "-20.48~20.45 (m/s²)" 2313 "-20.48~20.45 (m/s²)" 2314 "-20.48~20.45 (m/s²)" 2315 "-20.48~20.45 (m/s²)" 2316 "-20.48~20.45 (m/s²)" 2317 "-20.48~20.45 (m/s²)" 2318 "-20.48~20.45 (m/s²)" 2319 "-20.48~20.45 (m/s²)" 2320 "-20.48~20.45 (m/s²)" 2321 "-20.48~20.45 (m/s²)" 2322 "-20.48~20.45 (m/s²)" 2323 "-20.48~20.45 (m/s²)" 2324 "-20.48~20.45 (m/s²)" 2325 "-20.48~20.45 (m/s²)" 2326 "-20.48~20.45 (m/s²)" 2327 "-20.48~20.45 (m/s²)" 2328 "-20.48~20.45 (m/s²)" 2329 "-20.48~20.45 (m/s²)" 2330 "-20.48~20.45 (m/s²)" 2331 "-20.48~20.45 (m/s²)" 2332 "-20.48~20.45 (m/s²)" 2333 "-20.48~20.45 (m/s²)" 2334 "-20.48~20.45 (m/s²)" 2335 "-20.48~20.45 (m/s²)" 2336 "-20.48~20.45 (m/s²)" 2337 "-20.48~20.45 (m/s²)" 2338 "-20.48~20.45 (m/s²)" 2339 "-20.48~20.45 (m/s²)" 2340 "-20.48~20.45 (m/s²)" 2341 "-20.48~20.45 (m/s²)" 2342 "-20.48~20.45 (m/s²)" 2343 "-20.48~20.45 (m/s²)" 2344 "-20.48~20.45 (m/s²)" 2345 "-20.48~20.45 (m/s²)" 2346 "-20.48~20.45 (m/s²)" 2347 "-20.48~20.45 (m/s²)" 2348 "-20.48~20.45 (m/s²)" 2349 "-20.48~20.45 (m/s²)" 2350 "-20.48~20.45 (m/s²)" 2351 "-20.48~20.45 (m/s²)" 2352 "-20.48~20.45 (m/s²)" 2353 "-20.48~20.45 (m/s²)" 2354 "-20.48~20.45 (m/s²)" 2355 "-20.48~20.45 (m/s²)" 2356 "-20.48~20.45 (m/s²)" 2357 "-20.48~20.45 (m/s²)" 2358 "-20.48~20.45 (m/s²)" 2359 "-20.48~20.45 (m/s²)" 2360 "-20.48~20.45 (m/s²)" 2361 "-20.48~20.45 (m/s²)" 2362 "-20.48~20.45 (m/s²)" 2363 "-20.48~20.45 (m/s²)" 2364 "-20.48~20.45 (m/s²)" 2365 "-20.48~20.45 (m/s²)" 2366 "-20.48~20.45 (m/s²)" 2367 "-20.48~20.45 (m/s²)" 2368 "-20.48~20.45 (m/s²)" 2369 "-20.48~20.45 (m/s²)" 2370 "-20.48~20.45 (m/s²)" 2371 "-20.48~20.45 (m/s²)" 2372 "-20.48~20.45 (m/s²)" 2373 "-20.48~20.45 (m/s²)" 2374 "-20.48~20.45 (m/s²)" 2375 "-20.48~20.45 (m/s²)" 2376 "-20.48~20.45 (m/s²)" 2377 "-20.48~20.45 (m/s²)" 2378 "-20.48~20.45 (m/s²)" 2379 "-20.48~20.45 (m/s²)" 2380 "-20.48~20.45 (m/s²)" 2381 "-20.48~20.45 (m/s²)" 2382 "-20.48~20.45 (m/s²)" 2383 "-20.48~20.45 (m/s²)" 2384 "-20.48~20.45 (m/s²)" 2385 "-20.48~20.45 (m/s²)" 2386 "-20.48~20.45 (m/s²)" 2387 "-20.48~20.45 (m/s²)" 2388 "-20.48~20.45 (m/s²)" 2389 "-20.48~20.45 (m/s²)" 2390 "-20.48~20.45 (m/s²)" 2391 "-20.48~20.45 (m/s²)" 2392 "-20.48~20.45 (m/s²)" 2393 "-20.48~20.45 (m/s²)" 2394 "-20.48~20.45 (m/s²)" 2395 "-20.48~20.45 (m/s²)" 2396 "-20.48~20.45 (m/s²)" 2397 "-20.48~20.45 (m/s²)" 2398 "-20.48~20.45 (m/s²)" 2399 "-20.48~20.45 (m/s²)" 2400 "-20.48~20.45 (m/s²)" 2401 "-20.48~20.45 (m/s²)" 2402 "-20.48~20.45 (m/s²)" 2403 "-20.48~20.45 (m/s²)" 2404 "-20.48~20.45 (m/s²)" 2405 "-20.48~20.45 (m/s²)" 2406 "-20.48~20.45 (m/s²)" 2407 "-20.48~20.45 (m/s²)" 2408 "-20.48~20.45 (m/s²)" 2409 "-20.48~20.45 (m/s²)" 2410 "-20.48~20.45 (m/s²)" 2411 "-20.48~20.45 (m/s²)" 2412 "-20.48~20.45 (m/s²)" 2413 "-20.48~20.45 (m/s²)" 2414 "-20.48~20.45 (m/s²)" 2415 "-20.48~20.45 (m/s²)" 2416 "-20.48~20.45 (m/s²)" 2417 "-20.48~20.45 (m/s²)" 2418 "-20.48~20.45 (m/s²)" 2419 "-20.48~20.45 (m/s²)" 2420 "-20.48~20.45 (m/s²)" 2421 "-20.48~20.45 (m/s²)" 2422 "-20.48~20.45 (m/s²)" 2423 "-20.48~20.45 (m/s²)" 2424 "-20.48~20.45 (m/s²)" 2425 "-20.48~20.45 (m/s²)" 2426 "-20.48~20.45 (m/s²)" 2427 "-20.48~20.45 (m/s²)" 2428 "-20.48~20.45 (m/s²)" 2429 "-20.48~20.45 (m/s²)" 2430 "-20.48~20.45 (m/s²)" 2431 "-20.48~20.45 (m/s²)" 2432 "-20.48~20.45 (m/s²)" 2433 "-20.48~20.45 (m/s²)" 2434 "-20.48~20.45 (m/s²)" 2435 "-20.48~20.45 (m/s²)" 2436 "-20.48~20.45 (m/s²)" 2437 "-20.48~20.45 (m/s²)" 2438 "-20.48~20.45 (m/s²)" 2439 "-20.48~20.45 (m/s²)" 2440 "-20.48~20.45 (m/s²)" 2441 "-20.48~20.45 (m/s²)" 2442 "-20.48~20.45 (m/s²)" 2443 "-20.48~20.45 (m/s²)" 2444 "-20.48~20.45 (m/s²)" 2445 "-20.48~20.45 (m/s²)" 2446 "-20.48~20.45 (m/s²)" 2447 "-20.48~20.45 (m/s²)" 2448 "-20.48~20.45 (m/s²)" 2449 "-20.48~20.45 (m/s²)" 2450 "-20.48~20.45 (m/s²)" 2451 "-20.48~20.45 (m/s²)" 2452 "-20.48~20.45 (m/s²)" 2453 "-20.48~20.45 (m/s²)" 2454 "-20.48~20.45 (m/s²)" 2455 "-20.48~20.45 (m/s²)" 2456 "-20.48~20.45 (m/s²)" 2457 "-20.48~20.45 (m/s²)" 2458 "-20.48~20.45 (m/s²)" 2459 "-20.48~20.45 (m/s²)" 2460 "-20.48~20.45 (m/s²)" 2461 "-20.48~20.45 (m/s²)" 2462 "-20.48~20.45 (m/s²)" 2463 "-20.48~20.45 (m/s²)" 2464 "-20.48~20.45 (m/s²)" 2465 "-20.48~20.45 (m/s²)" 2466 "-20.48~20.45 (m/s²)" 2467 "-20.48~20.45 (m/s²)" 2468 "-20.48~20.45 (m/s²)" 2469 "-20.48~20.45 (m/s²)" 2470 "-20.48~20.45 (m/s²)" 2471 "-20.48~20.45 (m/s²)" 2472 "-20.48~20.45 (m/s²)" 2473 "-20.48~20.45 (m/s²)" 2474 "-20.48~20.45 (m/s²)" 2475 "-20.48~20.45 (m/s²)" 2476 "-20.48~20.45 (m/s²)" 2477 "-20.48~20.45 (m/s²)" 2478 "-20.48~20.45 (m/s²)" 2479 "-20.48~20.45 (m/s²)" 2480 "-20.48~20.45 (m/s²)" 2481 "-20.48~20.45 (m/s²)" 2482 "-20.48~20.45 (m/s²)" 2483 "-20.48~20.45 (m/s²)" 2484 "-20.48~20.45 (m/s²)" 2485 "-20.48~20.45 (m/s²)" 2486 "-20.48~20.45 (m/s²)" 2487 "-20.48~20.45 (m/s²)" 2488 "-20.48~20.45 (m/s²)" 2489 "-20.48~20.45 (m/s²)" 2490 "-20.48~20.45 (m/s²)" 2491 "-20.48~20.45 (m/s²)" 2492 "-20.48~20.45 (m/s²)" 2493 "-20.48~20.45 (m/s²)" 2494 "-20.48~20.45 (m/s²)" 2495 "-20.48~20.45 (m/s²)" 2496 "-20.48~20.45 (m/s²)" 2497 "-20.48~20.45 (m/s²)" 2498 "-20.48~20.45 (m/s²)" 2499 "-20.48~20.45 (m/s²)" 2500 "-20.48~20.45 (m/s²)" 2501 "-20.48~20.45 (m/s²)" 2502 "-20.48~20.45 (m/s²)" 2503 "-20.48~20.45 (m/s²)" 2504 "-20.48~20.45 (m/s²)" 2505 "-20.48~20.45 (m/s²)" 2506 "-20.48~20.45 (m/s²)" 2507 "-20.48~20.45 (m/s²)" 2508 "-20.48~20.45 (m/s²)" 2509 "-20.48~20.45 (m/s²)" 2510 "-20.48~20.45 (m/s²)" 2511 "-20.48~20.45 (m/s²)" 2512 "-20.48~20.45 (m/s²)" 2513 "-20.48~20.45 (m/s²)" 2514 "-20.48~20.45 (m/s²)" 2515 "-20.48~20.45 (m/s²)" 2516 "-20.48~20.45 (m/s²)" 2517 "-20.48~20.45 (m/s²)" 2518 "-20.48~20.45 (m/s²)" 2519 "-20.48~20.45 (m/s²)" 2520 "-20.48~20.45 (m/s²)" 2521 "-20.48~20.45 (m/s²)" 2522 "-20.48~20.45 (m/s²)" 2523 "-20.48~20.45 (m/s²)" 2524 "-20.48~20.45 (m/s²)" 2525 "-20.48~20.45 (m/s²)" 2526 "-20.48~20.45 (m/s²)" 2527 "-20.48~20.45 (m/s²)" 2528 "-20.48~20.45 (m/s²)" 2529 "-20.48~20.45 (m/s²)" 2530 "-20.48~20.45 (m/s²)" 2531 "-20.48~20.45 (m/s²)" 2532 "-20.48~20.45 (m/s²)" 2533 "-20.48~20.45 (m/s²)" 2534 "-20.48~20.45 (m/s²)" 2535 "-20.48~20.45 (m/s²)" 2536 "-20.48~20.45 (m/s²)" 2537 "-20.48~20.45 (m/s²)" 2538 "-20.48~20.45 (m/s²)" 2539 "-20.48~20.45 (m/s²)" 2540 "-20.48~20.45 (m/s²)" 2541 "-20.48~20.45 (m/s²)" 2542 "-20.48~20.45 (m/s²)" 2543 "-20.48~20.45 (m/s²)" 2544 "-20.48~20.45 (m/s²)" 2545 "-20.48~20.45 (m/s²)" 2546 "-20.48~20.45 (m/s²)" 2547 "-20.48~20.45 (m/s²)" 2548 "-20.48~20.45 (m/s²)" 2549 "-20.48~20.45 (m/s²)" 2550 "-20.48~20.45 (m/s²)" 2551 "-20.48~20.45 (m/s²)" 2552 "-20.48~20.45 (m/s²)" 2553 "-20.48~20.45 (m/s²)" 2554 "-20.48~20.45 (m/s²)" 2555 "-20.48~20.45 (m/s²)" 2556 "-20.48~20.45 (m/s²)" 2557 "-20.48~20.45 (m/s²)" 2558 "-20.48~20.45 (m/s²)" 2559 "-20.48~20.45 (m/s²)" 2560 "-20.48~20.45 (m/s²)" 2561 "-20.48~20.45 (m/s²)" 2562 "-20.48~20.45 (m/s²)" 2563 "-20.48~20.45 (m/s²)" 2564 "-20.48~20.45 (m/s²)" 2565 "-20.48~20.45 (m/s²)" 2566 "-20.48~20.45 (m/s²)" 2567 "-20.48~20.45 (m/s²)" 2568 "-20.48~20.45 (m/s²)" 2569 "-20.48~20.45 (m/s²)" 2570 "-20.48~20.45 (m/s²)" 2571 "-20.48~20.45 (m/s²)" 2572 "-20.48~20.45 (m/s²)" 2573 "-20.48~20.45 (m/s²)" 2574 "-20.48~20.45 (m/s²)" 2575 "-20.48~20.45 (m/s²)" 2576 "-20.48~20.45 (m/s²)" 2577 "-20.48~20.45 (m/s²)" 2578 "-20.48~20.45 (m/s²)" 2579 "-20.48~20.45 (m/s²)" 2580 "-20.48~20.45 (m/s²)" 2581 "-20.48~20.45 (m/s²)" 2582 "-20.48~20.45 (m/s²)" 2583 "-20.48~20.45 (m/s²)" 2584 "-20.48~20.45 (m/s²)" 2585 "-20.48~20.45 (m/s²)" 2586 "-20.48~20.45 (m/s²)" 2587 "-20.48~20.45 (m/s²)" 2588 "-20.48~20.45 (m/s²)" 2589 "-20.48~20.45 (m/s²)" 2590 "-20.48~20.45 (m/s²)" 2591 "-20.48~20.45 (m/s²)" 2592 "-20.48~20.45 (m/s²)" 2593 "-20.48~20.45 (m/s²)" 2594 "-20.48~20.45 (m/s²)" 2595 "-20.48~20.45 (m/s²)" 2596 "-20.48~20.45 (m/s²)" 2597 "-20.48~20.45 (m/s²)" 2598 "-20.48~20.45 (m/s²)" 2599 "-20.48~20.45 (m/s²)" 2600 "-20.48~20.45 (m/s²)" 2601 "-20.48~20.45 (m/s²)" 2602 "-20.48~20.45 (m/s²)" 2603 "-20.48~20.45 (m/s²)" 2604 "-20.48~20.45 (m/s²)" 2605 "-20.48~20.45 (m/s²)" 2606 "-20.48~20.45 (m/s²)" 2607 "-20.48~20.45 (m/s²)" 2608 "-20.48~20.45 (m/s²)" 2609 "-20.48~20.45 (m/s²)" 2610 "-20.48~20.45 (m/s²)" 2611 "-20.48~20.45 (m/s²)" 2612 "-20.48~20.45 (m/s²)" 2613 "-20.48~20.45 (m/s²)" 2614 "-20.48~20.45 (m/s²)" 2615 "-20.48~20.45 (m/s²)" 2616 "-20.48~20.45 (m/s²)" 2617 "-20.48~20.45 (m/s²)" 2618 "-20.48~20.45 (m/s²)" 2619 "-20.48~20.45 (m/s²)" 2620 "-20.48~20.45 (m/s²)" 2621 "-20.48~20.45 (m/s²)" 2622 "-20.48~20.45 (m/s²)" 2623 "-20.48~20.45 (m/s²)" 2624 "-20.48~20.45 (m/s²)" 2625 "-20.48~20.45 (m/s²)" 2626 "-20.48~20.45 (m/s²)" 2627 "-20.48~20.45 (m/s²)" 2628 "-20.48~20.45 (m/s²)" 2629 "-20.48~20.45 (m/s²)" 2630 "-20.48~20.45 (m/s²)" 2631 "-20.48~20.45 (m/s²)" 2632 "-20.48~20.45 (m/s²)" 2633 "-20.48~20.45 (m/s²)" 2634 "-20.48~20.45 (m/s²)" 2635 "-20.48~20.45 (m/s²)" 2636 "-20.48~20.45 (m/s²)" 2637 "-20.48~20.45 (m/s²)" 2638 "-20.48~20.45 (m/s²)" 2639 "-20.48~20.45 (m/s²)" 2640 "-20.48~20.45 (m/s²)" 2641 "-20.48~20.45 (m/s²)" 2642 "-20.48~20.45 (m/s²)" 2643 "-20.48~20.45 (m/s²)" 2644 "-20.48~20.45 (m/s²)" 2645 "-20.48~20.45 (m/s²)" 2646 "-20.48~20.45 (m/s²)" 2647 "-20.48~20.45 (m/s²)" 2648 "-20.48~20.45 (m/s²)" 2649 "-20.48~20.45 (m/s²)" 2650 "-20.48~20.45 (m/s²)" 2651 "-20.48~20.45 (m/s²)" 2652 "-20.48~20.45 (m/s²)" 2653 "-20.48~20.45 (m/s²)" 2654 "-20.48~20.45 (m/s²)" 2655 "-20.48~20.45 (m/s²)" 2656 "-20.48~20.45 (m/s²)" 2657 "-20.48~20.45 (m/s²)" 2658 "-20.48~20.45 (m/s²)" 2659 "-20.48~20.45 (m/s²)" 2660 "-20.48~20.45 (m/s²)" 2661 "-20.48~20.45 (m/s²)" 2662 "-20.48~20.45 (m/s²)" 2663 "-20.48~20.45 (m/s²)" 2664 "-20.48~20.45 (m/s²)" 2665 "-20.48~20.45 (m/s²)" 2666 "-20.48~20.45 (m/s²)" 2667 "-20.48~20.45 (m/s²)" 2668 "-20.48~20.45 (m/s²)" 2669 "-20.48~20.45 (m/s²)" 2670 "-20.48~20.45 (m/s²)" 2671 "-20.48~20.45 (m/s²)" 2672 "-20.48~20.45 (m/s²)" 2673 "-20.48~20.45 (m/s²)" 2674 "-20.48~20.45 (m/s²)" 2675 "-20.48~20.45 (m/s²)" 2676 "-20.48~20.45 (m/s²)" 2677 "-20.48~20.45 (m/s²)" 2678 "-20.48~20.45 (m/s²)" 2679 "-20.48~20.45 (m/s²)" 2680 "-20.48~20.45 (m/s²)" 2681 "-20.48~20.45 (m/s²)" 2682 "-20.48~20.45 (m/s²)" 2683 "-20.48~20.45 (m/s²)" 2684 "-20.48~20.45 (m/s²)" 2685 "-20.48~20.45 (m/s²)" 2686 "-20.48~20.45 (m/s²)" 2687 "-20.48~20.45 (m/s²)" 2688 "-20.48~20.45 (m/s²)" 2689 "-20.48~20.45 (m/s²)" 2690 "-20.48~20.45 (m/s²)" 2691 "-20.48~20.45 (m/s²)" 2692 "-20.48~20.45 (m/s²)" 2693 "-20.48~20.45 (m/s²)" 2694 "-20.48~20.45 (m/s²)" 2695 "-20.48~20.45 (m/s²)" 2696 "-20.48~20.45 (m/s²)" 2697 "-20.48~20.45 (m/s²)" 2698 "-20.48~20.45 (m/s²)" 2699 "-20.48~20.45 (m/s²)" 2700 "-20.48~20.45 (m/s²)" 2701 "-20.48~20.45 (m/s²)" 2702 "-20.48~20.45 (m/s²)" 2703 "-20.48~20.45 (m/s²)" 2704 "-20.48~20.45 (m/s²)" 2705 "-20.48~20.45 (m/s²)" 2706 "-20.48~20.45 (m/s²)" 2707 "-20.48~20.45 (m/s²)" 2708 "-20.48~20.45 (m/s²)" 2709 "-20.48~20.45 (m/s²)" 2710 "-20.48~20.45 (m/s²)" 2711 "-20.48~20.45 (m/s²)" 2712 "-20.48~20.45 (m/s²)" 2713 "-20.48~20.45 (m/s²)" 2714 "-20.48~20.45 (m/s²)" 2715 "-20.48~20.45 (m/s²)" 2716 "-20.48~20.45 (m/s²)" 2717 "-20.48~20.45 (m/s²)" 2718 "-20.48~20.45 (m/s²)" 2719 "-20.48~20.45 (m/s²)" 2720 "-20.48~20.45 (m/s²)" 2721 "-20.48~20.45 (m/s²)" 2722 "-20.48~20.45 (m/s²)" 2723 "-20.48~20.45 (m/s²)" 2724 "-20.48~20.45 (m/s²)" 2725 "-20.48~20.45 (m/s²)" 2726 "-20.48~20.45 (m/s²)" 2727 "-20.48~20.45 (m/s²)" 2728 "-20.48~20.45 (m/s²)" 2729 "-20.48~20.45 (m/s²)" 2730 "-20.48~20.45 (m/s²)" 2731 "-20.48~20.45 (m/s²)" 2732 "-20.48~20.45 (m/s²)" 2733 "-20.48~20.45 (m/s²)" 2734 "-20.48~20.45 (m/s²)" 2735 "-20.48~20.45 (m/s²)" 2736 "-20.48~20.45 (m/s²)" 2737 "-20.48~20.45 (m/s²)" 2738 "-20.48~20.45 (m/s²)" 2739 "-20.48~20.45 (m/s²)" 2740 "-20.48~20.45 (m/s²)" 2741 "-20.48~20.45 (m/s²)" 2742 "-20.48~20.45 (m/s²)" 2743 "-20.48~20.45 (m/s²)" 2744 "-20.48~20.45 (m/s²)" 2745 "-20.48~20.45 (m/s²)" 2746 "-20.48~20.45 (m/s²)" 2747 "-20.48~20.45 (m/s²)" 2748 "-20.48~20.45 (m/s²)" 2749 "-20.48~20.45 (m/s²)" 2750 "-20.48~20.45 (m/s²)" 2751 "-20.48~20.45 (m/s²)" 2752 "-20.48~20.45 (m/s²)" 2753 "-20.48~20.45 (m/s²)" 2754 "-20.48~20.45 (m/s²)" 2755 "-20.48~20.45 (m/s²)" 2756 "-20.48~20.45 (m/s²)" 2757 "-20.48~20.45 (m/s²)" 2758 "-20.48~20.45 (m/s²)" 2759 "-20.48~20.45 (m/s²)" 2760 "-20.48~20.45 (m/s²)" 2761 "-20.48~20.45 (m/s²)" 2762 "-20.48~20.45 (m/s²)" 2763 "-20.48~20.45 (m/s²)" 2764 "-20.48~20.45 (m/s²)" 2765 "-20.48~20.45 (m/s²)" 2766 "-20.48~20.45 (m/s²)" 2767 "-20.48~20.45 (m/s²)" 2768 "-20.48~20.45 (m/s²)" 2769 "-20.48~20.45 (m/s²)" 2770 "-20.48~20.45 (m/s²)" 2771 "-20.48~20.45 (m/s²)" 2772 "-20.48~20.45 (m/s²)" 2773 "-20.48~20.45 (m/s²)" 2774 "-20.48~20.45 (m/s²)" 2775 "-20.48~20.45 (m/s²)" 2776 "-20.48~20.45 (m/s²)" 2777 "-20.48~20.45 (m/s²)" 2778 "-20.48~20.45 (m/s²)" 2779 "-20.48~20.45 (m/s²)" 2780 "-20.48~20.45 (m/s²)" 2781 "-20.48~20.45 (m/s²)" 2782 "-20.48~20.45 (m/s²)" 2783 "-20.48~20.45 (m/s²)" 2784 "-20.48~20.45 (m/s²)" 2785 "-20.48~20.45 (m/s²)" 2786 "-20.48~20.45 (m/s²)" 2787 "-20.48~20.45 (m/s²)" 2788 "-20.48~20.45 (m/s²)" 2789 "-20.48~20.45 (m/s²)" 2790 "-20.48~20.45 (m/s²)" 2791 "-20.48~20.45 (m/s²)" 2792 "-20.48~20.45 (m/s²)" 2793 "-20.48~20.45 (m/s²)" 2794 "-20.48~20.45 (m/s²)" 2795 "-20.48~20.45 (m/s²)" 2796 "-20.48~20.45 (m/s²)" 2797 "-20.48~20.45 (m/s²)" 2798 "-20.48~20.45 (m/s²)" 2799 "-20.48~20.45 (m/s²)" 2800 "-20.48~20.45 (m/s²)" 2801 "-20.48~20.45 (m/s²)" 2802 "-20.48~20.45 (m/s²)" 2803 "-20.48~20.45 (m/s²)" 2804 "-20.48~20.45 (m/s²)" 2805 "-20.48~20.45 (m/s²)" 2806 "-20.48~20.45 (m/s²)" 2807 "-20.48~20.45 (m/s²)" 2808 "-20.48~20.45 (m/s²)" 2809 "-20.48~20.45 (m/s²)" 2810 "-20.48~20.45 (m/s²)" 2811 "-20.48~20.45 (m/s²)" 2812 "-20.48~20.45 (m/s²)" 2813 "-20.48~20.45 (m/s²)" 2814 "-20.48~20.45 (m/s²)" 2815 "-20.48~20.45 (m/s²)" 2816 "-20.48~20.45 (m/s²)" 2817 "-20.48~20.45 (m/s²)" 2818 "-20.48~20.45 (m/s²)" 2819 "-20.48~20.45 (m/s²)" 2820 "-20.48~20.45 (m/s²)" 2821 "-20.48~20.45 (m/s²)" 2822 "-20.48~20.45 (m/s²)" 2823 "-20.48~20.45 (m/s²)" 2824 "-20.48~20.45 (m/s²)" 2825 "-20.48~20.45 (m/s²)" 2826 "-20.48~20.45 (m/s²)" 2827 "-20.48~20.45 (m/s²)" 2828 "-20.48~20.45 (m/s²)" 2829 "-20.48~20.45 (m/s²)" 2830 "-20.48~20.45 (m/s²)" 2831 "-20.48~20.45 (m/s²)" 2832 "-20.48~20.45 (m/s²)" 2833 "-20.48~20.45 (m/s²)" 2834 "-20.48~20.45 (m/s²)" 2835 "-20.48~20.45 (m/s²)" 2836 "-20.48~20.45 (m/s²)" 2837 "-20.48~20.45 (m/s²)" 2838 "-20.48~20.45 (m/s²)" 2839 "-20.48~20.45 (m/s²)" 2840 "-20.48~20.45 (m/s²)" 2841 "-20.48~20.45 (m/s²)" 2842 "-20.48~20.45 (m/s²)" 2843 "-20.48~20.45 (m/s²)" 2844 "-20.48~20.45 (m/s²)" 2845 "-20.48~20.45 (m/s²)" 2846 "-20.48~20.45 (m/s²)" 2847 "-20.48~20.45 (m/s²)" 2848 "-20.48~20.45 (m/s²)" 2849 "-20.48~20.45 (m/s²)" 2850 "-20.48~20.45 (m/s²)" 2851 "-20.48~20.45 (m/s²)" 2852 "-20.48~20.45 (m/s²)" 2853 "-20.48~20.45 (m/s²)" 2854 "-20.48~20.45 (m/s²)" 2855 "-20.48~20.45 (m/s²)" 2856 "-20.48~20.45 (m/s²)" 2857 "-20.48~20.45 (m/s²)" 2858 "-20.48~20.45 (m/s²)" 2859 "-20.48~20.45 (m/s²)" 2860 "-20.48~20.45 (m/s²)" 2861 "-20.48~20.45 (m/s²)" 2862 "-20.48~20.45 (m/s²)" 2863 "-20.48~20.45 (m/s²)" 2864 "-20.48~20.45 (m/s²)" 2865 "-20.48~20.45 (m/s²)" 2866 "-20.48~20.45 (m/s²)" 2867 "-20.48~20.45 (m/s²)" 2868 "-20.48~20.45 (m/s²)" 2869 "-20.48~20.45 (m/s²)" 2870 "-20.48~20.45 (m/s²)" 2871 "-20.48~20.45 (m/s²)" 2872 "-20.48~20.45 (m/s²)" 2873 "-20.48~20.45 (m/s²)" 2874 "-20.48~20.45 (m/s²)" 2875 "-20.48~20.45 (m/s²)" 2876 "-20.48~20.45 (m/s²)" 2877 "-20.48~20.45 (m/s²)" 2878 "-20.48~20.45 (m/s²)" 2879 "-20.48~20.45 (m/s²)" 2880 "-20.48~20.45 (m/s²)" 2881 "-20.48~20.45 (m/s²)" 2882 "-20.48~20.45 (m/s²)" 2883 "-20.48~20.45 (m/s²)" 2884 "-20.48~20.45 (m/s²)" 2885 "-20.48~20.45 (m/s²)" 2886 "-20.48~20.45 (m/s²)" 2887 "-20.48~20.45 (m/s²)" 2888 "-20.48~20.45 (m/s²)" 2889 "-20.48~20.45 (m/s²)" 2890 "-20.48~20.45 (m/s²)" 2891 "-20.48~20.45 (m/s²)" 2892 "-20.48~20.45 (m/s²)" 2893 "-20.48~20.45 (m/s²)" 2894 "-20.48~20.45 (m/s²)" 2895 "-20.48~20.45 (m/s²)" 2896 "-20.48~20.45 (m/s²)" 2897 "-20.48~20.45 (m/s²)" 2898 "-20.48~20.45 (m/s²)" 2899 "-20.48~20.45 (m/s²)" 2900 "-20.48~20.45 (m/s²)" 2901 "-20.48~20.45 (m/s²)" 2902 "-20.48~20.45 (m/s²)" 2903 "-20.48~20.45 (m/s²)" 2904 "-20.48~20.45 (m/s²)" 2905 "-20.48~20.45 (m/s²)" 2906 "-20.48~20.45 (m/s²)" 2907 "-20.48~20.45 (m/s²)" 2908 "-20.48~20.45 (m/s²)" 2909 "-20.48~20.45 (m/s²)" 2910 "-20.48~20.45 (m/s²)" 2911 "-20.48~20.45 (m/s²)" 2912 "-20.48~20.45 (m/s²)" 2913 "-20.48~20.45 (m/s²)" 2914 "-20.48~20.45 (m/s²)" 2915 "-20.48~20.45 (m/s²)" 2916 "-20.48~20.45 (m/s²)" 2917 "-20.48~20.45 (m/s²)" 2918 "-20.48~20.45 (m/s²)" 2919 "-20.48~20.45 (m/s²)" 2920 "-20.48~20.45 (m/s²)" 2921 "-20.48~20.45 (m/s²)" 2922 "-20.48~20.45 (m/s²)" 2923 "-20.48~20.45 (m/s²)" 2924 "-20.48~20.45 (m/s²)" 2925 "-20.48~20.45 (m/s²)" 2926 "-20.48~20.45 (m/s²)" 2927 "-20.48~20.45 (m/s²)" 2928 "-20.48~20.45 (m/s²)" 2929 "-20.48~20.45 (m/s²)" 2930 "-20.48~20.45 (m/s²)" 2931 "-20.48~20.45 (m/s²)" 2932 "-20.48~20.45 (m/s²)" 2933 "-20.48~20.45 (m/s²)" 2934 "-20.48~20.45 (m/s²)" 2935 "-20.48~20.45 (m/s²)" 2936 "-20.48~20.45 (m/s²)" 2937 "-20.48~20.45 (m/s²)" 2938 "-20.48~20.45 (m/s²)" 2939 "-20.48~20.45 (m/s²)" 2940 "-20.48~20.45 (m/s²)" 2941 "-20.48~20.45 (m/s²)" 2942 "-20.48~20.45 (m/s²)" 2943 "-20.48~20.45 (m/s²)" 2944 "-20.48~20.45 (m/s²)" 2945 "-20.48~20.45 (m/s²)" 2946 "-20.48~20.45 (m/s²)" 2947 "-20.48~20.45 (m/s²)" 2948 "-20.48~20.45 (m/s²)" 2949 "-20.48~20.45 (m/s²)" 2950 "-20.48~20.45 (m/s²)" 2951 "-20.48~20.45 (m/s²)" 2952 "-20.48~20.45 (m/s²)" 2953 "-20.48~20.45 (m/s²)" 2954 "-20.48~20.45 (m/s²)" 2955 "-20.48~20.45 (m/s²)" 2956 "-20.48~20.45 (m/s²)" 2957 "-20.48~20.45 (m/s²)" 2958 "-20.48~20.45 (m/s²)" 2959 "-20.48~20.45 (m/s²)" 2960 "-20.48~20.45 (m/s²)" 2961 "-20.48~20.45 (m/s²)" 2962 "-20.48~20.45 (m/s²)" 2963 "-20.48~20.45 (m/s²)" 2964 "-20.48~20.45 (m/s²)" 2965 "-20.48~20.45 (m/s²)" 2966 "-20.48~20.45 (m/s²)" 2967 "-20.48~20.45 (m/s²)" 2968 "-20.48~20.45 (m/s²)" 2969 "-20.48~20.45 (m/s²)" 2970 "-20.48~20.45 (m/s²)" 2971 "-20.48~20.45 (m/s²)" 2972 "-20.48~20.45 (m/s²)" 2973 "-20.48~20.45 (m/s²)" 2974 "-20.48~20.45 (m/s²)" 2975 "-20.48~20.45 (m/s²)" 2976 "-20.48~20.45 (m/s²)" 2977 "-20.48~20.45 (m/s²)" 2978 "-20.48~20.45 (m/s²)" 2979 "-20.48~20.45 (m/s²)" 2980 "-20.48~20.45 (m/s²)" 2981 "-20.48~20.45 (m/s²)" 2982 "-20.48~20.45 (m/s²)" 2983 "-20.48~20.45 (m/s²)" 2984 "-20.48~20.45 (m/s²)" 2985 "-20.48~20.45 (m/s²)" 2986 "-20.48~20.45 (m/s²)" 2987 "-20.48~20.45 (m/s²)" 2988 "-20.48~20.45 (m/s²)" 2989 "-20.48~20.45 (m/s²)" 2990 "-20.48~20.45 (m/s²)" 2991 "-20.48~20.45 (m/s²)" 2992 "-20.48~20.45 (m/s²)" 2993 "-20.48~20.45 (m/s²)" 2994 "-20.48~20.45 (m/s²)" 2995 "-20.48~20.45 (m/s²)" 2996 "-20.48~20.45 (m/s²)" 2997 "-20.48~20.45 (m/s²)" 2998 "-20.48~20.45 (m/s²)" 2999 "-20.48~20.45 (m/s²)" 3000 "-20.48~20.45 (m/s²)" 3001 "-20.48~20.45 (m/s²)" 3002 "-20.48~20.45 (m/s²)" 3003 "-20.48~20.45 (m/s²)" 3004 "-20.48~20.45 (m/s²)" 3005 "-20.48~20.45 (m/s²)" 3006 "-20.48~20.45 (m/s²)" 3007 "-20.48~20.45 (m/s²)" 3008 "-20.48~20.45 (m/s²)" 3009 "-20.48~20.45 (m/s²)" 3010 "-20.48~20.45 (m/s²)" 3011 "-20.48~20.45 (m/s²)" 3012 "-20.48~20.45 (m/s²)" 3013 "-20.48~20.45 (m/s²)" 3014 "-20.48~20.45 (m/s²)" 3015 "-20.48~20.45 (m/s²)" 3016 "-20.48~20.45 (m/s²)" 3017 "-20.48~20.45 (m/s²)" 3018 "-20.48~20.45 (m/s²)" 3019 "-20.48~20.45 (m/s²)" 3020 "-20.48~20.45 (m/s²)" 3021 "-20.48~20.45 (m/s²)" 3022 "-20.48~20.45 (m/s²)" 3023 "-20.48~20.45 (m/s²)" 3024 "-20.48~20.45 (m/s²)" 3025 "-20.48~20.45 (m/s²)" 3026 "-20.48~20.45 (m/s²)" 3027 "-20.48~20.45 (m/s²)" 3028 "-20.48~20.45 (m/s²)" 3029 "-20.48~20.45 (m/s²)" 3030 "-20.48~20.45 (m/s²)" 3031 "-20.48~20.45 (m/s²)" 3032 "-20.48~20.45 (m/s²)" 3033 "-20.48~20.45 (m/s²)" 3034 "-20.48~20.45 (m/s²)" 3035 "-20.48~20.45 (m/s²)" 3036 "-20.48~20.45 (m/s²)" 3037 "-20.48~20.45 (m/s²)" 3038 "-20.48~20.45 (m/s²)" 3039 "-20.48~20.45 (m/s²)" 3040 "-20.48~20.45 (m/s²)" 3041 "-20.48~20.45 (m/s²)" 3042 "-20.48~20.45 (m/s²)" 3043 "-20.48~20.45 (m/s²)" 3044 "-20.48~20.45 (m/s²)" 3045 "-20.48~20.45 (m/s²)" 3046 "-20.48~20.45 (m/s²)" 3047 "-20.48~20.45 (m/s²)" 3048 "-20.48~20.45 (m/s²)" 3049 "-20.48~20.45 (m/s²)" 3050 "-20.48~20.45 (m/s²)" 3051 "-20.48~20.45 (m/s²)" 3052 "-20.48~20.45 (m/s²)" 3053 "-20.48~20.45 (m/s²)" 3054 "-20.48~20.45 (m/s²)" 3055 "-20.48~20.45 (m/s²)" 3056 "-20.48~20.45 (m/s²)" 3057 "-20.48~20.45 (m/s²)" 3058 "-20.48~20.45 (m/s²)" 3059 "-20.48~20.45 (m/s²)" 3060 "-20.48~20.45 (m/s²)" 3061 "-20.48~20.45 (m/s²)" 3062 "-20.48~20.45 (m/s²)" 3063 "-20.48~20.45 (m/s²)" 3064 "-20.48~20.45 (m/s²)" 3065 "-20.48~20.45 (m/s²)" 3066 "-20.48~20.45 (m/s²)" 3067 "-20.48~20.45 (m/s²)" 3068 "-20.48~20.45 (m/s²)" 3069 "-20.48~20.45 (m/s²)" 3070 "-20.48~20.45 (m/s²)" 3071 "-20.48~20.45 (m/s²)" 3072 "-20.48~20.45 (m/s²)" 3073 "-20.48~20.45 (m/s²)" 3074 "-20.48~20.45 (m/s²)" 3075 "-20.48~20.45 (m/s²)" 3076 "-20.48~20.45 (m/s²)" 3077 "-20.48~20.45 (m/s²)" 3078 "-20.48~20.45 (m/s²)" 3079 "-20.48~20.45 (m/s²)" 3080 "-20.48~20.45 (m/s²)" 3081 "-20.48~20.45 (m/s²)" 3082 "-20.48~20.45 (m/s²)" 3083 "-20.48~20.45 (m/s²)" 3084 "-20.48~20.45 (m/s²)" 3085 "-20.48~20.45 (m/s²)" 3086 "-20.48~20.45 (m/s²)" 3087 "-20.48~20.45 (m/s²)" 3088 "-20.48~20.45 (m/s²)" 3089 "-20.48~20.45 (m/s²)" 3090 "-20.48~20.45 (m/s²)" 3091 "-20.48~20.45 (m/s²)" 3092 "-20.48~20.45 (m/s²)" 3093 "-20.48~20.45 (m/s²)" 3094 "-20.48~20.45 (m/s²)" 3095 "-20.48~20.45 (m/s²)" 3096 "-20.48~20.45 (m/s²)" 3097 "-20.48~20.45 (m/s²)" 3098 "-20.48~20.45 (m/s²)" 3099 "-20.48~20.45 (m/s²)" 3100 "-20.48~20.45 (m/s²)" 3101 "-20.48~20.45 (m/s²)" 3102 "-20.48~20.45 (m/s²)" 3103 "-20.48~20.45 (m/s²)" 3104 "-20.48~20.45 (m/s²)" 3105 "-20.48~20.45 (m/s²)" 3106 "-20.48~20.45 (m/s²)" 3107 "-20.48~20.45 (m/s²)" 3108 "-20.48~20.45 (m/s²)" 3109 "-20.48~20.45 (m/s²)" 3110 "-20.48~20.45 (m/s²)" 3111 "-20.48~20.45 (m/s²)" 3112 "-20.48~20.45 (m/s²)" 3113 "-20.48~20.45 (m/s²)" 3114 "-20.48~20.45 (m/s²)" 3115 "-20.48~20.45 (m/s²)" 3116 "-20.48~20.45 (m/s²)" 3117 "-20.48~20.45 (m/s²)" 3118 "-20.48~20.45 (m/s²)" 3119 "-20.48~20.45 (m/s²)" 3120 "-20.48~20.45 (m/s²)" 3121 "-20.48~20.45 (m/s²)" 3122 "-20.48~20.45 (m/s²)" 3123 "-20.48~20.45 (m/s²)" 3124 "-20.48~20.45 (m/s²)" 3125 "-20.48~20.45 (m/s²)" 3126 "-20.48~20.45 (m/s²)" 3127 "-20.48~20.45 (m/s²)" 3128 "-20.48~20.45 (m/s²)" 3129 "-20.48~20.45 (m/s²)" 3130 "-20.48~20.45 (m/s²)" 3131 "-20.48~20.45 (m/s²)" 3132 "-20.48~20.45 (m/s²)" 3133 "-20.48~20.45 (m/s²)" 3134 "-20.48~20.45 (m/s²)" 3135 "-20.48~20.45 (m/s²)" 3136 "-20.48~20.45 (m/s²)" 3137 "-20.48~20.45 (m/s²)" 3138 "-20.48~20.45 (m/s²)" 3139 "-20.48~20.45 (m/s²)" 3140 "-20.48~20.45 (m/s²)" 3141 "-20.48~20.45 (m/s²)" 3142 "-20.48~20.45 (m/s²)" 3143 "-20.48~20.45 (m/s²)" 3144 "-20.48~20.45 (m/s²)" 3145 "-20.48~20.45 (m/s²)" 3146 "-20.48~20.45 (m/s²)" 3147 "-20.48~20.45 (m/s²)" 3148 "-20.48~20.45 (m/s²)" 3149 "-20.48~20.45 (m/s²)" 3150 "-20.48~20.45 (m/s²)" 3151 "-20.48~20.45 (m/s²)" 3152 "-20.48~20.45 (m/s²)" 3153 "-20.48~20.45 (m/s²)" 3154 "-20.48~20.45 (m/s²)" 3155 "-20.48~20.45 (m/s²)" 3156 "-20.48~20.45 (m/s²)" 3157 "-20.48~20.45 (m/s²)" 3158 "-20.48~20.45 (m/s²)" 3159 "-20.48~20.45 (m/s²)" 3160 "-20.48~20.45 (m/s²)" 3161 "-20.48~20.45 (m/s²)" 3162 "-20.48~20.45 (m/s²)" 3163 "-20.48~20.45 (m/s²)" 3164 "-20.48~20.45 (m/s²)" 3165 "-20.48~20.45 (m/s²)" 3166 "-20.48~20.45 (m/s²)" 3167 "-20.48~20.45 (m/s²)" 3168 "-20.48~20.45 (m/s²)" 3169 "-20.48~20.45 (m/s²)" 3170 "-20.48~20.45 (m/s²)" 3171 "-20.48~20.45 (m/s²)" 3172 "-20.48~20.45 (m/s²)" 3173 "-20.48~20.45 (m/s²)" 3174 "-20.48~20.45 (m/s²)" 3175 "-20.48~20.45 (m/s²)" 3176 "-20.48~20.45 (m/s²)" 3177 "-20.48~20.45 (m/s²)" 3178 "-20.48~20.45 (m/s²)" 3179 "-20.48~20.45 (m/s²)" 3180 "-20.48~20.45 (m/s²)" 3181 "-20.48~20.45 (m/s²)" 3182 "-20.48~20.45 (m/s²)" 3183 "-20.48~20.45 (m/s²)" 3184 "-20.48~20.45 (m/s²)" 3185 "-20.48~20.45 (m/s²)" 3186 "-20.48~20.45 (m/s²)" 3187 "-20.48~20.45 (m/s²)" 3188 "-20.48~20.45 (m/s²)" 3189 "-20.48~20.45 (m/s²)" 3190 "-20.48~20.45 (m/s²)" 3191 "-20.48~20.45 (m/s²)" 3192 "-20.48~20.45 (m/s²)" 3193 "-20.48~20.45 (m/s²)" 3194 "-20.48~20.45 (m/s²)" 3195 "-20.48~20.45 (m/s²)" 3196 "-20.48~20.45 (m/s²)" 3197 "-20.48~20.45 (m/s²)" 3198 "-20.48~20.45 (m/s²)" 3199 "-20.48~20.45 (m/s²)" 3200 "-20.48~20.45 (m/s²)" 3201 "-20.48~20.45 (m/s²)" 3202 "-20.48~20.45 (m/s²)" 3203 "-20.48~20.45 (m/s²)" 3204 "-20.48~20.45 (m/s²)" 3205 "-20.48~20.45 (m/s²)" 3206 "-20.48~20.45 (m/s²)" 3207 "-20.48~20.45 (m/s²)" 3208 "-20.48~20.45 (m/s²)" 3209 "-20.48~20.45 (m/s²)" 3210 "-20.48~20.45 (m/s²)" 3211 "-20.48~20.45 (m/s²)" 3212 "-20.48~20.45 (m/s²)" 3213 "-20.48~20.45 (m/s²)" 3214 "-20.48~20.45 (m/s²)" 3215 "-20.48~20.45 (m/s²)" 3216 "-20.48~20.45 (m/s²)" 3217 "-20.48~20.45 (m/s²)" 3218 "-20.48~20.45 (m/s²)" 3219 "-20.48~20.45 (m/s²)" 3220 "-20.48~20.45 (m/s²)" 3221 "-20.48~20.45 (m/s²)" 3222 "-20.48~20.45 (m/s²)" 3223 "-20.48~20.45 (m/s²)" 3224 "-20.48~20.45 (m/s²)" 3225 "-20.48~20.45 (m/s²)" 3226 "-20.48~20.45 (m/s²)" 3227 "-20.48~20.45 (m/s²)" 3228 "-20.48~20.45 (m/s²)" 3229 "-20.48~20.45 (m/s²)" 3230 "-20.48~20.45 (m/s²)" 3231 "-20.48~20.45 (m/s²)" 3232 "-20.48~20.45 (m/s²)" 3233 "-20.48~20.45 (m/s²)" 3234 "-20.48~20.45 (m/s²)" 3235 "-20.48~20.45 (m/s²)" 3236 "-20.48~20.45 (m/s²)" 3237 "-20.48~20.45 (m/s²)" 3238 "-20.48~20.45 (m/s²)" 3239 "-20.48~20.45 (m/s²)" 3240 "-20.48~20.45 (m/s²)" 3241 "-20.48~20.45 (m/s²)" 3242 "-20.48~20.45 (m/s²)" 3243 "-20.48~20.45 (m/s²)" 3244 "-20.48~20.45 (m/s²)" 3245 "-20.48~20.45 (m/s²)" 3246 "-20.48~20.45 (m/s²)" 3247 "-20.48~20.45 (m/s²)" 3248 "-20.48~20.45 (m/s²)" 3249 "-20.48~20.45 (m/s²)" 3250 "-20.48~20.45 (m/s²)" 3251 "-20.48~20.45 (m/s²)" 3252 "-20.48~20.45 (m/s²)" 3253 "-20.48~20.45 (m/s²)" 3254 "-20.48~20.45 (m/s²)" 3255 "-20.48~20.45 (m/s²)" 3256 "-20.48~20.45 (m/s²)" 3257 "-20.48~20.45 (m/s²)" 3258 "-20.48~20.45 (m/s²)" 3259 "-20.48~20.45 (m/s²)" 3260 "-20.48~20.45 (m/s²)" 3261 "-20.48~20.45 (m/s²)" 3262 "-20.48~20.45 (m/s²)" 3263 "-20.48~20.45 (m/s²)" 3264 "-20.48~20.45 (m/s²)" 3265 "-20.48~20.45 (m/s²)" 3266 "-20.48~20.45 (m/s²)" 3267 "-20.48~20.45 (m/s²)" 3268 "-20.48~20.45 (m/s²)" 3269 "-20.48~20.45 (m/s²)" 3270 "-20.48~20.45 (m/s²)" 3271 "-20.48~20.45 (m/s²)" 3272 "-20.48~20.45 (m/s²)" 3273 "-20.48~20.45 (m/s²)" 3274 "-20.48~20.45 (m/s²)" 3275 "-20.48~20.45 (m/s²)" 3276 "-20.48~20.45 (m/s²)" 3277 "-20.48~20.45 (m/s²)" 3278 "-20.48~20.45 (m/s²)" 3279 "-20.48~20.45 (m/s²)" 3280 "-20.48~20.45 (m/s²)" 3281 "-20.48~20.45 (m/s²)" 3282 "-20.48~20.45 (m/s²)" 3283 "-20.48~20.45 (m/s²)" 3284 "-20.48~20.45 (m/s²)" 3285 "-20.48~20.45 (m/s²)" 3286 "-20.48~20.45 (m/s²)" 3287 "-20.48~20.45 (m/s²)" 3288 "-20.48~20.45 (m/s²)" 3289 "-20.48~20.45 (m/s²)" 3290 "-20.48~20.45 (m/s²)" 3291 "-20.48~20.45 (m/s²)" 3292 "-20.48~20.45 (m/s²)" 3293 "-20.48~20.45 (m/s²)" 3294 "-20.48~20.45 (m/s²)" 3295 "-20.48~20.45 (m/s²)" 3296 "-20.48~20.45 (m/s²)" 3297 "-20.48~20.45 (m/s²)" 3298 "-20.48~20.45 (m/s²)" 3299 "-20.48~20.45 (m/s²)" 3300 "-20.48~20.45 (m/s²)" 3301 "-20.48~20.45 (m/s²)" 3302 "-20.48~20.45 (m/s²)" 3303 "-20.48~20.45 (m/s²)" 3304 "-20.48~20.45 (m/s²)" 3305 "-20.48~20.45 (m/s²)" 3306 "-20.48~20.45 (m/s²)" 3307 "-20.48~20.45 (m/s²)" 3308 "-20.48~20.45 (m/s²)" 3309 "-20.48~20.45 (m/s²)" 3310 "-20.48~20.45 (m/s²)" 3311 "-20.48~20.45 (m/s²)" 3312 "-20.48~20.45 (m/s²)" 3313 "-20.48~20.45 (m/s²)" 3314 "-20.48~20.45 (m/s²)" 3315 "-20.48~20.45 (m/s²)" 3316 "-20.48~20.45 (m/s²)" 3317 "-20.48~20.45 (m/s²)" 3318 "-20.48~20.45 (m/s²)" 3319 "-20.48~20.45 (m/s²)" 3320 "-20.48~20.45 (m/s²)" 3321 "-20.48~20.45 (m/s²)" 3322 "-20.48~20.45 (m/s²)" 3323 "-20.48~20.45 (m/s²)" 3324 "-20.48~20.45 (m/s²)" 3325 "-20.48~20.45 (m/s²)" 3326 "-20.48~20.45 (m/s²)" 3327 "-20.48~20.45 (m/s²)" 3328 "-20.48~20.45 (m/s²)" 3329 "-20.48~20.45 (m/s²)" 3330 "-20.48~20.45 (m/s²)" 3331 "-20.48~20.45 (m/s²)" 3332 "-20.48~20.45 (m/s²)" 3333 "-20.48~20.45 (m/s²)" 3334 "-20.48~20.45 (m/s²)" 3335 "-20.48~20.45 (m/s²)" 3336 "-20.48~20.45 (m/s²)" 3337 "-20.48~20.45 (m/s²)" 3338 "-20.48~20.45 (m/s²)" 3339 "-20.48~20.45 (m/s²)" 3340 "-20.48~20.45 (m/s²)" 3341 "-20.48~20.45 (m/s²)" 3342 "-20.48~20.45 (m/s²)" 3343 "-20.48~20.45 (m/s²)" 3344 "-20.48~20.45 (m/s²)" 3345 "-20.48~20.45 (m/s²)" 3346 "-20.48~20.45 (m/s²)" 3347 "-20.48~20.45 (m/s²)" 3348 "-20.48~20.45 (m/s²)" 3349 "-20.48~20.45 (m/s²)" 3350 "-20.48~20.45 (m/s²)" 3351 "-20.48~20.45 (m/s²)" 3352 "-20.48~20.45 (m/s²)" 3353 "-20.48~20.45 (m/s²)" 3354 "-20.48~20.45 (m/s²)" 3355 "-20.48~20.45 (m/s²)" 3356 "-20.48~20.45 (m/s²)" 3357 "-20.48~20.45 (m/s²)" 3358 "-20.48~20.45 (m/s²)" 3359 "-20.48~20.45 (m/s²)" 3360 "-20.48~20.45 (m/s²)" 3361 "-20.48~20.45 (m/s²)" 3362 "-20.48~20.45 (m/s²)" 3363 "-20.48~20.45 (m/s²)" 3364 "-20.48~20.45 (m/s²)" 3365 "-20.48~20.45 (m/s²)" 3366 "-20.48~20.45 (m/s²)" 3367 "-20.48~20.45 (m/s²)" 3368 "-20.48~20.45 (m/s²)" 3369 "-20.48~20.45 (m/s²)" 3370 "-20.48~20.45 (m/s²)" 3371 "-20.48~20.45 (m/s²)" 3372 "-20.48~20.45 (m/s²)" 3373 "-20.48~20.45 (m/s²)" 3374 "-20.48~20.45 (m/s²)" 3375 "-20.48~20.45 (m/s²)" 3376 "-20.48~20.45 (m/s²)" 3377 "-20.48~20.45 (m/s²)" 3378 "-20.48~20.45 (m/s²)" 3379 "-20.48~20.45 (m/s²)" 3380 "-20.48~20.45 (m/s²)" 3381 "-20.48~20.45 (m/s²)" 3382 "-20.48~20.45 (m/s²)" 3383 "-20.48~20.45 (m/s²)" 3384 "-20.48~20.45 (m/s²)" 3385 "-20.48~20.45 (m/s²)" 3386 "-20.48~20.45 (m/s²)" 3387 "-20.48~20.45 (m/s²)" 3388 "-20.48~20.45 (m/s²)" 3389 "-20.48~20.45 (m/s²)" 3390 "-20.48~20.45 (m/s²)" 3391 "-20.48~20.45 (m/s²)" 3392 "-20.48~20.45 (m/s²)" 3393 "-20.48~20.45 (m/s²)" 3394 "-20.48~20.45 (m/s²)" 3395 "-20.48~20.45 (m/s²)" 3396 "-20.48~20.45 (m/s²)" 3397 "-20.48~20.45 (m/s²)" 3398 "-20.48~20.45 (m/s²)" 3399 "-20.48~20.45 (m/s²)" 3400 "-20.48~20.45 (m/s²)" 3401 "-20.48~20.45 (m/s²)" 3402 "-20.48~20.45 (m/s²)" 3403 "-20.48~20.45 (m/s²)" 3404 "-20.48~20.45 (m/s²)" 3405 "-20.48~20.45 (m/s²)" 3406 "-20.48~20.45 (m/s²)" 3407 "-20.48~20.45 (m/s²)" 3408 "-20.48~20.45 (m/s²)" 3409 "-20.48~20.45 (m/s²)" 3410 "-20.48~20.45 (m/s²)" 3411 "-20.48~20.45 (m/s²)" 3412 "-20.48~20.45 (m/s²)" 3413 "-20.48~20.45 (m/s²)" 3414 "-20.48~20.45 (m/s²)" 3415 "-20.48~20.45 (m/s²)" 3416 "-20.48~20.45 (m/s²)" 3417 "-20.48~20.45 (m/s²)" 3418 "-20.48~20.45 (m/s²)" 3419 "-20.48~20.45 (m/s²)" 3420 "-20.48~20.45 (m/s²)" 3421 "-20.48~20.45 (m/s²)" 3422 "-20.48~20.45 (m/s²)" 3423 "-20.48~20.45 (m/s²)" 3424 "-20.48~20.45 (m/s²)" 3425 "-20.48~20.45 (m/s²)" 3426 "-20.48~20.45 (m/s²)" 3427 "-20.48~20.45 (m/s²)" 3428 "-20.48~20.45 (m/s²)" 3429 "-20.48~20.45 (m/s²)" 3430 "-20.48~20.45 (m/s²)" 3431 "-20.48~20.45 (m/s²)" 3432 "-20.48~20.45 (m/s²)" 3433 "-20.48~20.45 (m/s²)" 3434 "-20.48~20.45 (m/s²)" 3435 "-20.48~20.45 (m/s²)" 3436 "-20.48~20.45 (m/s²)" 3437 "-20.48~20.45 (m/s²)" 3438 "-20.48~20.45 (m/s²)" 3439 "-20.48~20.45 (m/s²)" 3440 "-20.48~20.45 (m/s²)" 3441 "-20.48~20.45 (m/s²)" 3442 "-20.48~20.45 (m/s²)" 3443 "-20.48~20.45 (m/s²)" 3444 "-20.48~20.45 (m/s²)" 3445 "-20.48~20.45 (m/s²)" 3446 "-20.48~20.45 (m/s²)" 3447 "-20.48~20.45 (m/s²)" 3448 "-20.48~20.45 (m/s²)" 3449 "-20.48~20.45 (m/s²)" 3450 "-20.48~20.45 (m/s²)" 3451 "-20.48~20.45 (m/s²)" 3452 "-20.48~20.45 (m/s²)" 3453 "-20.48~20.45 (m/s²)" 3454 "-20.48~20.45 (m/s²)" 3455 "-20.48~20.45 (m/s²)" 3456 "-20.48~20.45 (m/s²)" 3457 "-20.48~20.45 (m/s²)" 3458 "-20.48~20.45 (m/s²)" 3459 "-20.48~20.45 (m/s²)" 3460 "-20.48~20.45 (m/s²)" 3461 "-20.48~20.45 (m/s²)" 3462 "-20.48~20.45 (m/s²)" 3463 "-20.48~20.45 (m/s²)" 3464 "-20.48~20.45 (m/s²)" 3465 "-20.48~20.45 (m/s²)" 3466 "-20.48~20.45 (m/s²)" 3467 "-20.48~20.45 (m/s²)" 3468 "-20.48~20.45 (m/s²)" 3469 "-20.48~20.45 (m/s²)" 3470 "-20.48~20.45 (m/s²)" 3471 "-20.48~20.45 (m/s²)" 3472 "-20.48~20.45 (m/s²)" 3473 "-20.48~20.45 (m/s²)" 3474 "-20.48~20.45 (m/s²)" 3475 "-20.48~20.45 (m/s²)" 3476 "-20.48~20.45 (m/s²)" 3477 "-20.48~20.45 (m/s²)" 3478 "-20.48~20.45 (m/s²)" 3479 "-20.48~20.45 (m/s²)" 3480 "-20.48~20.45 (m/s²)" 3481 "-20.48~20.45 (m/s²)" 3482 "-20.48~20.45 (m/s²)" 3483 "-20.48~20.45 (m/s²)" 3484 "-20.48~20.45 (m/s²)" 3485 "-20.48~20.45 (m/s²)" 3486 "-20.48~20.45 (m/s²)" 3487 "-20.48~20.45 (m/s²)" 3488 "-20.48~20.45 (m/s²)" 3489 "-20.48~20.45 (m/s²)" 3490 "-20.48~20.45 (m/s²)" 3491 "-20.48~20.45 (m/s²)" 3492 "-20.48~20.45 (m/s²)" 3493 "-20.48~20.45 (m/s²)" 3494 "-20.48~20.45 (m/s²)" 3495 "-20.48~20.45 (m/s²)" 3496 "-20.48~20.45 (m/s²)" 3497 "-20.48~20.45 (m/s²)" 3498 "-20.48~20.45 (m/s²)" 3499 "-20.48~20.45 (m/s²)" 3500 "-20.48~20.45 (m/s²)" 3501 "-20.48~20.45 (m/s²)" 3502 "-20.48~20.45 (m/s²)" 3503 "-20.48~20.45 (m/s²)" 3504 "-20.48~20.45 (m/s²)" 3505 "-20.48~20.45 (m/s²)" 3506 "-20.48~20.45 (m/s²)" 3507 "-20.48~20.45 (m/s²)" 3508 "-20.48~20.45 (m/s²)" 3509 "-20.48~20.45 (m/s²)" 3510 "-20.48~20.45 (m/s²)" 3511 "-20.48~20.45 (m/s²)" 3512 "-20.48~20.45 (m/s²)" 3513 "-20.48~20.45 (m/s²)" 3514 "-20.48~20.45 (m/s²)" 3515 "-20.48~20.45 (m/s²)" 3516 "-20.48~20.45 (m/s²)" 3517 "-20.48~20.45 (m/s²)" 3518 "-20.48~20.45 (m/s²)" 3519 "-20.48~20.45 (m/s²)" 3520 "-20.48~20.45 (m/s²)" 3521 "-20.48~20.45 (m/s²)" 3522 "-20.48~20.45 (m/s²)" 3523 "-20.48~20.45 (m/s²)" 3524 "-20.48~20.45 (m/s²)" 3525 "-20.48~20.45 (m/s²)" 3526 "-20.48~20.45 (m/s²)" 3527 "-20.48~20.45 (m/s²)" 3528 "-20.48~20.45 (m/s²)" 3529 "-20.48~20.45 (m/s²)" 3530 "-20.48~20.45 (m/s²)" 3531 "-20.48~20.45 (m/s²)" 3532 "-20.48~20.45 (m/s²)" 3533 "-20.48~20.45 (m/s²)" 3534 "-20.48~20.45 (m/s²)" 3535 "-20.48~20.45 (m/s²)" 3536 "-20.48~20.45 (m/s²)" 3537 "-20.48~20.45 (m/s²)" 3538 "-20.48~20.45 (m/s²)" 3539 "-20.48~20.45 (m/s²)" 3540 "-20.48~20.45 (m/s²)" 3541 "-20.48~20.45 (m/s²)" 3542 "-20.48~20.45 (m/s²)" 3543 "-20.48~20.45 (m/s²)" 3544 "-20.48~20.45 (m/s²)" 3545 "-20.48~20.45 (m/s²)" 3546 "-20.48~20.45 (m/s²)" 3547 "-20.48~20.45 (m/s²)" 3548 "-20.48~20.45 (m/s²)" 3549 "-20.48~20.45 (m/s²)" 3550 "-20.48~20.45 (m/s²)" 3551 "-20.48~20.45 (m/s²)" 3552 "-20.48~20.45 (m/s²)" 3553 "-20.48~20.45 (m/s²)" 3554 "-20.48~20.45 (m/s²)" 3555 "-20.48~20.45 (m/s²)" 3556 "-20.48~20.45 (m/s²)" 3557 "-20.48~20.45 (m/s²)" 3558 "-20.48~20.45 (m/s²)" 3559 "-20.48~20.45 (m/s²)" 3560 "-20.48~20.45 (m/s²)" 3561 "-20.48~20.45 (m/s²)" 3562 "-20.48~20.45 (m/s²)" 3563 "-20.48~20.45 (m/s²)" 3564 "-20.48~20.45 (m/s²)" 3565 "-20.48~20.45 (m/s²)" 3566 "-20.48~20.45 (m/s²)" 3567 "-20.48~20.45 (m/s²)" 3568 "-20.48~20.45 (m/s²)" 3569 "-20.48~20.45 (m/s²)" 3570 "-20.48~20.45 (m/s²)" 3571 "-20.48~20.45 (m/s²)" 3572 "-20.48~20.45 (m/s²)" 3573 "-20.48~20.45 (m/s²)" 3574 "-20.48~20.45 (m/s²)" 3575 "-20.48~20.45 (m/s²)" 3576 "-20.48~20.45 (m/s²)" 3577 "-20.48~20.45 (m/s²)" 3578 "-20.48~20.45 (m/s²)" 3579 "-20.48~20.45 (m/s²)" 3580 "-20.48~20.45 (m/s²)" 3581 "-20.48~20.45 (m/s²)" 3582 "-20.48~20.45 (m/s²)" 3583 "-20.48~20.45 (m/s²)" 3584 "-20.48~20.45 (m/s²)" 3585 "-20.48~20.45 (m/s²)" 3586 "-20.48~20.45 (m/s²)" 3587 "-20.48~20.45 (m/s²)" 3588 "-20.48~20.45 (m/s²)" 3589 "-20.48~20.45 (m/s²)" 3590 "-20.48~20.45 (m/s²)" 3591 "-20.48~20.45 (m/s²)" 3592 "-20.48~20.45 (m/s²)" 3593 "-20.48~20.45 (m/s²)" 3594 "-20.48~20.45 (m/s²)" 3595 "-20.48~20.45 (m/s²)" 3596 "-20.48~20.45 (m/s²)" 3597 "-20.48~20.45 (m/s²)" 3598 "-20.48~20.45 (m/s²)" 3599 "-20.48~20.45 (m/s²)" 3600 "-20.48~20.45 (m/s²)" 3601 "-20.48~20.45 (m/s²)" 3602 "-20.48~20.45 (m/s²)" 3603 "-20.48~20.45 (m/s²)" 3604 "-20.48~20.45 (m/s²)" 3605 "-20.48~20.45 (m/s²)" 3606 "-20.48~20.45 (m/s²)" 3607 "-20.48~20.45 (m/s²)" 3608 "-20.48~20.45 (m/s²)" 3609 "-20.48~20.45 (m/s²)" 3610 "-20.48~20.45 (m/s²)" 3611 "-20.48~20.45 (m/s²)" 3612 "-20.48~20.45 (m/s²)" 3613 "-20.48~20.45 (m/s²)" 3614 "-20.48~20.45 (m/s²)" 3615 "-20.48~20.45 (m/s²)" 3616 "-20.48~20.45 (m/s²)" 3617 "-20.48~20.45 (m/s²)" 3618 "-20.48~20.45 (m/s²)" 3619 "-20.48~20.45 (m/s²)" 3620 "-20.48~20.45 (m/s²)" 3621 "-20.48~20.45 (m/s²)" 3622 "-20.48~20.45 (m/s²)" 3623 "-20.48~20.45 (m/s²)" 3624 "-20.48~20.45 (m/s²)" 3625 "-20.48~20.45 (m/s²)" 3626 "-20.48~20.45 (m/s²)" 3627 "-20.48~20.45 (m/s²)" 3628 "-20.48~20.45 (m/s²)" 3629 "-20.48~20.45 (m/s²)" 3630 "-20.48~20.45 (m/s²)" 3631 "-20.48~20.45 (m/s²)" 3632 "-20.48~20.45 (m/s²)" 3633 "-20.48~20.45 (m/s²)" 3634 "-20.48~20.45 (m/s²)" 3635 "-20.48~20.45 (m/s²)" 3636 "-20.48~20.45 (m/s²)" 3637 "-20.48~20.45 (m/s²)" 3638 "-20.48~20.45 (m/s²)" 3639 "-20.48~20.45 (m/s²)" 3640 "-20.48~20.45 (m/s²)" 3641 "-20.48~20.45 (m/s²)" 3642 "-20.48~20.45 (m/s²)" 3643 "-20.48~20.45 (m/s²)" 3644 "-20.48~20.45 (m/s²)" 3645 "-20.48~20.45 (m/s²)" 3646 "-20.48~20.45 (m/s²)" 3647 "-20.48~20.45 (m/s²)" 3648 "-20.48~20.45 (m/s²)" 3649 "-20.48~20.45 (m/s²)" 3650 "-20.48~20.45 (m/s²)" 3651 "-20.48~20.45 (m/s²)" 3652 "-20.48~20.45 (m/s²)" 3653 "-20.48~20.45 (m/s²)" 3654 "-20.48~20.45 (m/s²)" 3655 "-20.48~20.45 (m/s²)" 3656 "-20.48~20.45 (m/s²)" 3657 "-20.48~20.45 (m/s²)" 3658 "-20.48~20.45 (m/s²)" 3659 "-20.48~20.45 (m/s²)" 3660 "-20.48~20.45 (m/s²)" 3661 "-20.48~20.45 (m/s²)" 3662 "-20.48~20.45 (m/s²)" 3663 "-20.48~20.45 (m/s²)" 3664 "-20.48~20.45 (m/s²)" 3665 "-20.48~20.45 (m/s²)" 3666 "-20.48~20.45 (m/s²)" 3667 "-20.48~20.45 (m/s²)" 3668 "-20.48~20.45 (m/s²)" 3669 "-20.48~20.45 (m/s²)" 3670 "-20.48~20.45 (m/s²)" 3671 "-20.48~20.45 (m/s²)" 3672 "-20.48~20.45 (m/s²)" 3673 "-20.48~20.45 (m/s²)" 3674 "-20.48~20.45 (m/s²)" 3675 "-20.48~20.45 (m/s²)" 3676 "-20.48~20.45 (m/s²)" 3677 "-20.48~20.45 (m/s²)" 3678 "-20.48~20.45 (m/s²)" 3679 "-20.48~20.45 (m/s²)" 3680 "-20.48~20.45 (m/s²)" 3681 "-20.48~20.45 (m/s²)" 3682 "-20.48~20.45 (m/s²)" 3683 "-20.48~20.45 (m/s²)" 3684 "-20.48~20.45 (m/s²)" 3685 "-20.48~20.45 (m/s²)" 3686 "-20.48~20.45 (m/s²)" 3687 "-20.48~20.45 (m/s²)" 3688 "-20.48~20.45 (m/s²)" 3689 "-20.48~20.45 (m/s²)" 3690 "-20.48~20.45 (m/s²)" 3691 "-20.48~20.45 (m/s²)" 3692 "-20.48~20.45 (m/s²)" 3693 "-20.48~20.45 (m/s²)" 3694 "-20.48~20.45 (m/s²)" 3695 "-20.48~20.45 (m/s²)" 3696 "-20.48~20.45 (m/s²)" 3697 "-20.48~20.45 (m/s²)" 3698 "-20.48~20.45 (m/s²)" 3699 "-20.48~20.45 (m/s²)" 3700 "-20.48~20.45 (m/s²)" 3701 "-20.48~20.45 (m/s²)" 3702 "-20.48~20.45 (m/s²)" 3703 "-20.48~20.45 (m/s²)" 3704 "-20.48~20.45 (m/s²)" 3705 "-20.48~20.45 (m/s²)" 3706 "-20.48~20.45 (m/s²)" 3707 "-20.48~20.45 (m/s²)" 3708 "-20.48~20.45 (m/s²)" 3709 "-20.48~20.45 (m/s²)" 3710 "-20.48~20.45 (m/s²)" 3711 "-20.48~20.45 (m/s²)" 3712 "-20.48~20.45 (m/s²)" 3713 "-20.48~20.45 (m/s²)" 3714 "-20.48~20.45 (m/s²)" 3715 "-20.48~20.45 (m/s²)" 3716 "-20.48~20.45 (m/s²)" 3717 "-20.48~20.45 (m/s²)" 3718 "-20.48~20.45 (m/s²)" 3719 "-20.48~20.45 (m/s²)" 3720 "-20.48~20.45 (m/s²)" 3721 "-20.48~20.45 (m/s²)" 3722 "-20.48~20.45 (m/s²)" 3723 "-20.48~20.45 (m/s²)" 3724 "-20.48~20.45 (m/s²)" 3725 "-20.48~20.45 (m/s²)" 3726 "-20.48~20.45 (m/s²)" 3727 "-20.48~20.45 (m/s²)" 3728 "-20.48~20.45 (m/s²)" 3729 "-20.48~20.45 (m/s²)" 3730 "-20.48~20.45 (m/s²)" 3731 "-20.48~20.45 (m/s²)" 3732 "-20.48~20.45 (m/s²)" 3733 "-20.48~20.45 (m/s²)" 3734 "-20.48~20.45 (m/s²)" 3735 "-20.48~20.45 (m/s²)" 3736 "-20.48~20.45 (m/s²)" 3737 "-20.48~20.45 (m/s²)" 3738 "-20.48~20.45 (m/s²)" 3739 "-20.48~20.45 (m/s²)" 3740 "-20.48~20.45 (m/s²)" 3741 "-20.48~20.45 (m/s²)" 3742 "-20.48~20.45 (m/s²)" 3743 "-20.48~20.45 (m/s²)" 3744 "-20.48~20.45 (m/s²)" 3745 "-20.48~20.45 (m/s²)" 3746 "-20.48~20.45 (m/s²)" 3747 "-20.48~20.45 (m/s²)" 3748 "-20.48~20.45 (m/s²)" 3749 "-20.48~20.45 (m/s²)" 3750 "-20.48~20.45 (m/s²)" 3751 "-20.48~20.45 (m/s²)" 3752 "-20.48~20.45 (m/s²)" 3753 "-20.48~20.45 (m/s²)" 3754 "-20.48~20.45 (m/s²)" 3755 "-20.48~20.45 (m/s²)" 3756 "-20.48~20.45 (m/s²)" 3757 "-20.48~20.45 (m/s²)" 3758 "-20.48~20.45 (m/s²)" 3759 "-20.48~20.45 (m/s²)" 3760 "-20.48~20.45 (m/s²)" 3761 "-20.48~20.45 (m/s²)" 3762 "-20.48~20.45 (m/s²)" 3763 "-20.48~20.45 (m/s²)" 3764 "-20.48~20.45 (m/s²)" 3765 "-20.48~20.45 (m/s²)" 3766 "-20.48~20.45 (m/s²)" 3767 "-20.48~20.45 (m/s²)" 3768 "-20.48~20.45 (m/s²)" 3769 "-20.48~20.45 (m/s²)" 3770 "-20.48~20.45 (m/s²)" 3771 "-20.48~20.45 (m/s²)" 3772 "-20.48~20.45 (m/s²)" 3773 "-20.48~20.45 (m/s²)" 3774 "-20.48~20.45 (m/s²)" 3775 "-20.48~20.45 (m/s²)" 3776 "-20.48~20.45 (m/s²)" 3777 "-20.48~20.45 (m/s²)" 3778 "-20.48~20.45 (m/s²)" 3779 "-20.48~20.45 (m/s²)" 3780 "-20.48~20.45 (m/s²)" 3781 "-20.48~20.45 (m/s²)" 3782 "-20.48~20.45 (m/s²)" 3783 "-20.48~20.45 (m/s²)" 3784 "-20.48~20.45 (m/s²)" 3785 "-20.48~20.45 (m/s²)" 3786 "-20.48~20.45 (m/s²)" 3787 "-20.48~20.45 (m/s²)" 3788 "-20.48~20.45 (m/s²)" 3789 "-20.48~20.45 (m/s²)" 3790 "-20.48~20.45 (m/s²)" 3791 "-20.48~20.45 (m/s²)" 3792 "-20.48~20.45 (m/s²)" 3793 "-20.48~20.45 (m/s²)" 3794 "-20.48~20.45 (m/s²)" 3795 "-20.48~20.45 (m/s²)" 3796 "-20.48~20.45 (m/s²)" 3797 "-20.48~20.45 (m/s²)" 3798 "-20.48~20.45 (m/s²)" 3799 "-20.48~20.45 (m/s²)" 3800 "-20.48~20.45 (m/s²)" 3801 "-20.48~20.45 (m/s²)" 3802 "-20.48~20.45 (m/s²)" 3803 "-20.48~20.45 (m/s²)" 3804 "-20.48~20.45 (m/s²)" 3805 "-20.48~20.45 (m/s²)" 3806 "-20.48~20.45 (m/s²)" 3807 "-20.48~20.45 (m/s²)" 3808 "-20.48~20.45 (m/s²)" 3809 "-20.48~20.45 (m/s²)" 3810 "-20.48~20.45 (m/s²)" 3811 "-20.48~20.45 (m/s²)" 3812 "-20.48~20.45 (m/s²)" 3813 "-20.48~20.45 (m/s²)" 3814 "-20.48~20.45 (m/s²)" 3815 "-20.48~20.45 (m/s²)" 3816 "-20.48~20.45 (m/s²)" 3817 "-20.48~20.45 (m/s²)" 3818 "-20.48~20.45 (m/s²)" 3819 "-20.48~20.45 (m/s²)" 3820 "-20.48~20.45 (m/s²)" 3821 "-20.48~20.45 (m/s²)" 3822 "-20.48~20.45 (m/s²)" 3823 "-20.48~20.45 (m/s²)" 3824 "-20.48~20.45 (m/s²)" 3825 "-20.48~20.45 (m/s²)" 3826 "-20.48~20.45 (m/s²)" 3827 "-20.48~20.45 (m/s²)" 3828 "-20.48~20.45 (m/s²)" 3829 "-20.48~20.45 (m/s²)" 3830 "-20.48~20.45 (m/s²)" 3831 "-20.48~20.45 (m/s²)" 3832 "-20.48~20.45 (m/s²)" 3833 "-20.48~20.45 (m/s²)" 3834 "-20.48~20.45 (m/s²)" 3835 "-20.48~20.45 (m/s²)" 3836 "-20.48~20.45 (m/s²)" 3837 "-20.48~20.45 (m/s²)" 3838 "-20.48~20.45 (m/s²)" 3839 "-20.48~20.45 (m/s²)" 3840 "-20.48~20.45 (m/s²)" 3841 "-20.48~20.45 (m/s²)" 3842 "-20.48~20.45 (m/s²)" 3843 "-20.48~20.45 (m/s²)" 3844 "-20.48~20.45 (m/s²)" 3845 "-20.48~20.45 (m/s²)" 3846 "-20.48~20.45 (m/s²)" 3847 "-20.48~20.45 (m/s²)" 3848 "-20.48~20.45 (m/s²)" 3849 "-20.48~20.45 (m/s²)" 3850 "-20.48~20.45 (m/s²)" 3851 "-20.48~20.45 (m/s²)" 3852 "-20.48~20.45 (m/s²)" 3853 "-20.48~20.45 (m/s²)" 3854 "-20.48~20.45 (m/s²)" 3855 "-20.48~20.45 (m/s²)" 3856 "-20.48~20.45 (m/s²)" 3857 "-20.48~20.45 (m/s²)" 3858 "-20.48~20.45 (m/s²)" 3859 "-20.48~20.45 (m/s²)" 3860 "-20.48~20.45 (m/s²)" 3861 "-20.48~20.45 (m/s²)" 3862 "-20.48~20.45 (m/s²)" 3863 "-20.48~20.45 (m/s²)" 3864 "-20.48~20.45 (m/s²)" 3865 "-20.48~20.45 (m/s²)" 3866 "-20.48~20.45 (m/s²)" 3867 "-20.48~20.45 (m/s²)" 3868 "-20.48~20.45 (m/s²)" 3869 "-20.48~20.45 (m/s²)" 3870 "-20.48~20.45 (m/s²)" 3871 "-20.48~20.45 (m/s²)" 3872 "-20.48~20.45 (m/s²)" 3873 "-20.48~20.45 (m/s²)" 3874 "-20.48~20.45 (m/s²)" 3875 "-20.48~20.45 (m/s²)" 3876 "-20.48~20.45 (m/s²)" 3877 "-20.48~20.45 (m/s²)" 3878 "-20.48~20.45 (m/s²)" 3879 "-20.48~20.45 (m/s²)" 3880 "-20.48~20.45 (m/s²)" 3881 "-20.48~20.45 (m/s²)" 3882 "-20.48~20.45 (m/s²)" 3883 "-20.48~20.45 (m/s²)" 3884 "-20.48~20.45 (m/s²)" 3885 "-20.48~20.45 (m/s²)" 3886 "-20.48~20.45 (m/s²)" 3887 "-20.48~20.45 (m/s²)" 3888 "-20.48~20.45 (m/s²)" 3889 "-20.48~20.45 (m/s²)" 3890 "-20.48~20.45 (m/s²)" 3891 "-20.48~20.45 (m/s²)" 3892 "-20.48~20.45 (m/s²)" 3893 "-20.48~20.45 (m/s²)" 3894 "-20.48~20.45 (m/s²)" 3895 "-20.48~20.45 (m/s²)" 3896 "-20.48~20.45 (m/s²)" 3897 "-20.48~20.45 (m/s²)" 3898 "-20.48~20.45 (m/s²)" 3899 "-20.48~20.45 (m/s²)" 3900 "-20.48~20.45 (m/s²)" 3901 "-20.48~20.45 (m/s²)" 3902 "-20.48~20.45 (m/s²)" 3903 "-20.48~20.45 (m/s²)" 3904 "-20.48~20.45 (m/s²)" 3905 "-20.48~20.45 (m/s²)" 3906 "-20.48~20.45 (m/s²)" 3907 "-20.48~20.45 (m/s²)" 3908 "-20.48~20.45 (m/s²)" 3909 "-20.48~20.45 (m/s²)" 3910 "-20.48~20.45 (m/s²)" 3911 "-20.48~20.45 (m/s²)" 3912 "-20.48~20.45 (m/s²)" 3913 "-20.48~20.45 (m/s²)" 3914 "-20.48~20.45 (m/s²)" 3915 "-20.48~20.45 (m/s²)" 3916 "-20.48~20.45 (m/s²)" 3917 "-20.48~20.45 (m/s²)" 3918 "-20.48~20.45 (m/s²)" 3919 "-20.48~20.45 (m/s²)" 3920 "-20.48~20.45 (m/s²)" 3921 "-20.48~20.45 (m/s²)" 3922 "-20.48~20.45 (m/s²)" 3923 "-20.48~20.45 (m/s²)" 3924 "-20.48~20.45 (m/s²)" 3925 "-20.48~20.45 (m/s²)" 3926 "-20.48~20.45 (m/s²)" 3927 "-20.48~20.45 (m/s²)" 3928 "-20.48~20.45 (m/s²)" 3929 "-20.48~20.45 (m/s²)" 3930 "-20.48~20.45 (m/s²)" 3931 "-20.48~20.45 (m/s²)" 3932 "-20.48~20.45 (m/s²)" 3933 "-20.48~20.45 (m/s²)" 3934 "-20.48~20.45 (m/s²)" 3935 "-20.48~20.45 (m/s²)" 3936 "-20.48~20.45 (m/s²)" 3937 "-20.48~20.45 (m/s²)" 3938 "-20.48~20.45 (m/s²)" 3939 "-20.48~20.45 (m/s²)" 3940 "-20.48~20.45 (m/s²)" 3941 "-20.48~20.45 (m/s²)" 3942 "-20.48~20.45 (m/s²)" 3943 "-20.48~20.45 (m/s²)" 3944 "-20.48~20.45 (m/s²)" 3945 "-20.48~20.45 (m/s²)" 3946 "-20.48~20.45 (m/s²)" 3947 "-20.48~20.45 (m/s²)" 3948 "-20.48~20.45 (m/s²)" 3949 "-20.48~20.45 (m/s²)" 3950 "-20.48~20.45 (m/s²)" 3951 "-20.48~20.45 (m/s²)" 3952 "-20.48~20.45 (m/s²)" 3953 "-20.48~20.45 (m/s²)" 3954 "-20.48~20.45 (m/s²)" 3955 "-20.48~20.45 (m/s²)" 3956 "-20.48~20.45 (m/s²)" 3957 "-20.48~20.45 (m/s²)" 3958 "-20.48~20.45 (m/s²)" 3959 "-20.48~20.45 (m/s²)" 3960 "-20.48~20.45 (m/s²)" 3961 "-20.48~20.45 (m/s²)" 3962 "-20.48~20.45 (m/s²)" 3963 "-20.48~20.45 (m/s²)" 3964 "-20.48~20.45 (m/s²)" 3965 "-20.48~20.45 (m/s²)" 3966 "-20.48~20.45 (m/s²)" 3967 "-20.48~20.45 (m/s²)" 3968 "-20.48~20.45 (m/s²)" 3969 "-20.48~20.45 (m/s²)" 3970 "-20.48~20.45 (m/s²)" 3971 "-20.48~20.45 (m/s²)" 3972 "-20.48~20.45 (m/s²)" 3973 "-20.48~20.45 (m/s²)" 3974 "-20.48~20.45 (m/s²)" 3975 "-20.48~20.45 (m/s²)" 3976 "-20.48~20.45 (m/s²)" 3977 "-20.48~20.45 (m/s²)" 3978 "-20.48~20.45 (m/s²)" 3979 "-20.48~20.45 (m/s²)" 3980 "-20.48~20.45 (m/s²)" 3981 "-20.48~20.45 (m/s²)" 3982 "-20.48~20.45 (m/s²)" 3983 "-20.48~20.45 (m/s²)" 3984 "-20.48~20.45 (m/s²)" 3985 "-20.48~20.45 (m/s²)" 3986 "-20.48~20.45 (m/s²)" 3987 "-20.48~20.45 (m/s²)" 3988 "-20.48~20.45 (m/s²)" 3989 "-20.48~20.45 (m/s²)" 3990 "-20.48~20.45 (m/s²)" 3991 "-20.48~20.45 (m/s²)" 3992 "-20.48~20.45 (m/s²)" 3993 "-20.48~20.45 (m/s²)" 3994 "-20.48~20.45 (m/s²)" 3995 "-20.48~20.45 (m/s²)" 3996 "-20.48~20.45 (m/s²)" 3997 "-20.48~20.45 (m/s²)" 3998 "-20.48~20.45 (m/s²)" 3999 "-20.48~20.45 (m/s²)" 4000 "-20.48~20.45 (m/s²)" 4001 "-20.48~20.45 (m/s²)" 4002 "-20.48~20.45 (m/s²)" 4003 "-20.48~20.45 (m/s²)" 4004 "-20.48~20.45 (m/s²)" 4005 "-20.48~20.45 (m/s²)" 4006 "-20.48~20.45 (m/s²)" 4007 "-20.48~20.45 (m/s²)" 4008 "-20.48~20.45 (m/s²)" 4009 "-20.48~20.45 (m/s²)" 4010 "-20.48~20.45 (m/s²)" 4011 "-20.48~20.45 (m/s²)" 4012 "-20.48~20.45 (m/s²)" 4013 "-20.48~20.45 (m/s²)" 4014 "-20.48~20.45 (m/s²)" 4015 "-20.48~20.45 (m/s²)" 4016 "-20.48~20.45 (m/s²)" 4017 "-20.48~20.45 (m/s²)" 4018 "-20.48~20.45 (m/s²)" 4019 "-20.48~20.45 (m/s²)" 4020 "-20.48~20.45 (m/s²)" 4021 "-20.48~20.45 (m/s²)" 4022 "-20.48~20.45 (m/s²)" 4023 "-20.48~20.45 (m/s²)" 4024 "-20.48~20.45 (m/s²)" 4025 "-20.48~20.45 (m/s²)" 4026 "-20.48~20.45 (m/s²)" 4027 "-20.48~20.45 (m/s²)" 4028 "-20.48~20.45 (m/s²)" 4029 "-20.48~20.45 (m/s²)" 4030 "-20.48~20.45 (m/s²)" 4031 "-20.48~20.45 (m/s²)" 4032 "-20.48~20.45 (m/s²)" 4033 "-20.48~20.45 (m/s²)" 4034 "-20.48~20.45 (m/s²)" 4035 "-20.48~20.45 (m/s²)" 4036 "-20.48~20.45 (m/s²)" 4037 "-20.48~20.45 (m/s²)" 4038 "-20.48~20.45 (m/s²)" 4039 "-20.48~20.45 (m/s²)" 4040 "-20.48~20.45 (m/s²)" 4041 "-20.48~20.45 (m/s²)" 4042 "-20.48~20.45 (m/s²)" 4043 "-20.48~20.45 (m/s²)" 4044 "-20.48~20.45 (m/s²)" 4045 "-20.48~20.45 (m/s²)" 4046 "-20.48~20.45 (m/s²)" 4047 "-20.48~20.45 (m/s²)" 4048 "-20.48~20.45 (m/s²)" 4049 "-20.48~20.45 (m/s²)" 4050 "-20.48~20.45 (m/s²)" 4051 "-20.48~20.45 (m/s²)" 4052 "-20.48~20.45 (m/s²)" 4053 "-20.48~20.45 (m/s²)" 4054 "-20.48~20.45 (m/s²)" 4055 "-20.48~20.45 (m/s²)" 4056 "-20.48~20.45 (m/s²)" 4057 "-20.48~20.45 (m/s²)" 4058 "-20.48~20.45 (m/s²)" 4059 "-20.48~20.45 (m/s²)" 4060 "-20.48~20.45 (m/s²)" 4061 "-20.48~20.45 (m/s²)" 4062 "-20.48~20.45 (m/s²)" 4063 "-20.48~20.45 (m/s²)" 4064 "-20.48~20.45 (m/s²)" 4065 "-20.48~20.45 (m/s²)" 4066 "-20.48~20.45 (m/s²)" 4067 "-20.48~20.45 (m/s²)" 4068 "-20.48~20.45 (m/s²)" 4069 "-20.48~20.45 (m/s²)" 4070 "-20.48~20.45 (m/s²)" 4071 "-20.48~20.45 (m/s²)" 4072 "-20.48~20.45 (m/s²)" 4073 "-20.48~20.45 (m/s²)" 4074 "-20.48~20.45 (m/s²)" 4075 "-20.48~20.45 (m/s²)" 4076 "-20.48~20.45 (m/s²)" 4077 "-20.48~20.45 (m/s²)" 4078 "-20.48~20.45 (m/s²)" 4079 "-20.48~20.45 (m/s²)" 4080 "-20.48~20.45 (m/s²)" 4081 "-20.48~20.45 (m/s²)" 4082 "-20.48~20.45 (m/s²)" 4083 "-20.48~20.45 (m/s²)" 4084 "-20.48~20.45 (m/s²)" 4085 "-20.48~20.45 (m/s²)" 4086 "-20.48~20.45 (m/s²)" 4087 "-20.48~20.45 (m/s²)" 4088 "-20.48~20.45 (m/s²)" 4089 "-20.48~20.45 (m/s²)" 4090 "-20.48~20.45 (m/s²)" 4091 "-20.48~20.45 (m/s²)" 4092 "-20.48~20.45 (m/s²)" 4093 "-20.48~20.45 (m/s²)" 4094 "Not used" 4095 "Invalid" ;
VAL_ 122 ECSIVSS_RdIndxVal 0 "Normal" 1 "Small Rough" 2 "Small Wave" 4 "Bump" 8 "Big Rough" 10 "Long Wave" 14 "Not used" 15 "Invalid" ;
